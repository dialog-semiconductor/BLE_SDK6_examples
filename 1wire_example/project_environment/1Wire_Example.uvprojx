# Keil uVision project 1Wire_Example.uvprojx, settings and files
target 1Wire_Example_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 1Wire_Example_585 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: .\..\;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\include;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_custs;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_diss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_findme;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\em;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\lld;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\ea\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\em\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\hci\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\common_project_files;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\main;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\common\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\crypto;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\adc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\battery;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\ble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\gpio;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\reg;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_flash;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_hci;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\syscntl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\systick;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\trng;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\uart;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\dma;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\pdm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\rand;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\hash;..\src\user_drivers
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_585.txt" C:\DA14585_untouched_SDK\6.0.10.511\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=ble_app_peripheral_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/system_library/output/Keil_5/: system_library.lib
    C:/DA14585_untouched_SDK/6.0.10.511//third_party/rand/: chacha20.c
    C:/DA14585_untouched_SDK/6.0.10.511//third_party/hash/: hash.c
  group sdk_driver
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/syscntl/: syscntl.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/gpio/: gpio.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/battery/: battery.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/adc/: adc.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/trng/: trng.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/spi/: spi.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/uart/: uart2.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/hw_otpc/: hw_otpc.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/systick/: systick.h systick.c
  group sdk_ble
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/ble_stack/rwble/: rwble.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/core_modules/rwip/src/: rwip.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/core_modules/rf/src/: rf_585.c
  group sdk_profiles
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/ble_stack/profiles/: prf_utils.c prf.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/ble_stack/profiles/custom/: custom_common.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
  group sdk_app
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group sdk_driver_api
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/adc/: adc.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/battery/: battery.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/gpio/: gpio.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/spi/: spi.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/spi_flash/: spi_flash.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/systick/: systick.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/trng/: trng.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/uart/: uart.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/arch/: arch_api.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/arch/main/: arch_wdg.h
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c user_peripheral.c
  group user_drivers
    ../src/user_drivers/: one_wire.c one_wire.h user_uart.c user_uart.h
target 1Wire_Example_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: 1Wire_Example_586 +hex
  c flags: Optim=4 wLevel=2
  c define: __DA14586__
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: .\..\;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\include;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_custs;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_diss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_findme;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\em;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\lld;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\ea\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\em\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\hci\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\common_project_files;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\main;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\common\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\crypto;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\adc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\battery;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\ble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\gpio;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\reg;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_flash;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_hci;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\syscntl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\systick;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\trng;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\uart;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\dma;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\pdm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\rand;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\hash;..\src\user_drivers;.\..\;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\include;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_custs;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_diss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_findme;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\em;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\lld;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\ea\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\em\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\hci\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\common_project_files;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\main;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\common\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\crypto;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\adc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\battery;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\ble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\gpio;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\reg;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_flash;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_hci;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\syscntl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\systick;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\trng;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\uart;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\dma;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\pdm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\rand;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\hash;.\..\;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\include;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_custs;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_diss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_findme;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\em;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\lld;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\controller\llm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\ea\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\em\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\host\smp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\hci\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\common_project_files;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\main;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\common\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\crypto;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\adc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\battery;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\ble;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\gpio;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\reg;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_flash;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\spi_hci;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\syscntl;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\systick;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\trng;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\uart;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\rand;C:\DA14585_untouched_SDK\6.0.10.511\\third_party\hash;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_586.txt" C:\DA14585_untouched_SDK\6.0.10.511\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=ble_app_peripheral_symdef.txt --any_placement=best_fit --datacompressor off
