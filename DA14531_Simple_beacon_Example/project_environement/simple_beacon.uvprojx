# Keil uVision project simple_beacon.uvprojx, settings and files
target simple_beacon_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simple_beacon_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files\misc\da14585_symbols.txt    --symdefs=empty_peripheral_template_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/Release_sw_examples_585/6.0.11.989//third_party/rand/: chacha20.c
    C:/Release_sw_examples_585/6.0.11.989//third_party/hash/: hash.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/syscntl/: syscntl.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/gpio/: gpio.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/battery/: battery.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/trng/: trng.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/systick/: systick.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/uart/: uart.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/dma/: dma.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/driver/i2c/: i2c.c
  group sdk_ble
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/rwble/: rwble.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/bas/basc/src/: basc.c basc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/blp/blpc/src/: blpc.c blpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/blp/blps/src/: blps.c blps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/find/findt/src/: findt.c findt_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/htp/htpc/src/: htpc.c htpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/htp/htpt/src/: htpt.c htpt_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/anp/anpc/src/: anpc.c anpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/anp/anps/src/: anps.c anps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/glp/glpc/src/: glpc.c glpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/glp/glps/src/: glps.c glps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/tip/tipc/src/: tipc.c tipc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/tip/tips/src/: tips.c tips_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/find/findl/src/: findl.c findl_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/lan/lanc/src/: lanc.c lanc_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/lan/lans/src/: lans.c lans_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/custom/: custom_common.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/Release_sw_examples_585/6.0.11.989//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_simple_beacon.c
target simple_beacon_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: simple_beacon_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files\misc\da14585_symbols.txt    --symdefs=empty_peripheral_template_586_symdef.txt --any_placement=best_fit --datacompressor off
target simple_beacon_587 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: simple_beacon_587 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr;C:\Release_sw_examples_585\6.0.11.989\\sdk\app_modules\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\em;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\lld;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\controller\llm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\ea\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\em\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\hci\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\attm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\att\atts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gap\gapm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\gatt\gattm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\l2c\l2cm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\host\smp\smpm;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anc\ancc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\anp\anps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\basc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bas\bass\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bcs\bcss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\blp\blps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\bms\bmss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cpp\cpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cscp\cscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\cts\ctss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\custom\custs\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\disc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\dis\diss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\find\findt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\glp\glps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\hrp\hrps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\htp\htpt\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lanc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\lan\lans\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\paspc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\pasp\pasps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxm\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\prox\proxr\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\rscp\rscps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scppc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\scpp\scpps\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\suota\suotar\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tipc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\tip\tips\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udsc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\uds\udss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wssc\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\profiles\wss\wsss\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble;C:\Release_sw_examples_585\6.0.11.989\\sdk\ble_stack\rwble_hl;C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\boot\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\ARM;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\compiler\GCC;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\ll;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\arch\main;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\arch_console;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\common\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\crypto;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\dbg\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\gtl\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\h4tl\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\ke\src;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\nvds\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rf\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\core_modules\rwip\api;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\adc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\battery;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\ble;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\dma;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\gpio;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\hw_otpc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\i2c_eeprom;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\pdm;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\reg;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\rtc;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\spi_flash;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\syscntl;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\systick;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\timer;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\trng;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\uart;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\driver\wkupct_quadec;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\include;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\system_library\include;C:\Release_sw_examples_585\6.0.11.989\\third_party\hash;C:\Release_sw_examples_585\6.0.11.989\\third_party\irng;C:\Release_sw_examples_585\6.0.11.989\\third_party\rand;.\..\src;.\..\src\config;.\..\src\custom_profile;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_cs;C:\Release_sw_examples_585\6.0.11.989\\sdk\platform\utilities\otp_hdr
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\Release_sw_examples_585\6.0.11.989\\sdk\common_project_files\misc\da14531_symbols.txt   --symdefs=simple_beacon_symdef.txt --any_placement=best_fit --datacompressor off
