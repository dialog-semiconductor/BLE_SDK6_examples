# Keil uVision project timer1_general.uvprojx, settings and files
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: timer1_general_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __DA14531__ __NON_BLE_EXAMPLE__
  c misc: --thumb -c
  c include: C:\SDK\Timer1_SW_Example\src\;C:\SDK\6.0.12.1015\sdk\;C:\SDK\6.0.12.1015\sdk\app_modules\;C:\SDK\6.0.12.1015\sdk\app_modules\api\;C:\SDK\6.0.12.1015\sdk\app_modules\src\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_ancc\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_bass\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_bcss\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_bmss\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_bond_db\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_common\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_ctsc\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_ctss\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_custs\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_default_hnd\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_diss\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_easy\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_entry\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_findme\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_gattc\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_proxr\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_sec\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_suotar\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_udss\;C:\SDK\6.0.12.1015\sdk\app_modules\src\app_wsss\;C:\SDK\6.0.12.1015\sdk\ble_stack\;C:\SDK\6.0.12.1015\sdk\ble_stack\controller\;C:\SDK\6.0.12.1015\sdk\ble_stack\controller\em\;C:\SDK\6.0.12.1015\sdk\ble_stack\controller\llc\;C:\SDK\6.0.12.1015\sdk\ble_stack\controller\lld\;C:\SDK\6.0.12.1015\sdk\ble_stack\controller\llm\;C:\SDK\6.0.12.1015\sdk\ble_stack\ea\;C:\SDK\6.0.12.1015\sdk\ble_stack\ea\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\em\;C:\SDK\6.0.12.1015\sdk\ble_stack\em\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\hci\;C:\SDK\6.0.12.1015\sdk\ble_stack\hci\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\hci\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\att\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\att\attc\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\att\attm\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\att\atts\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\gap\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\gap\gapc\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\gap\gapm\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\gatt\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\gatt\gattc\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\gatt\gattm\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\l2c\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\l2c\l2cc\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\l2c\l2cm\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\smp\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\smp\smpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\host\smp\smpm\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anc\ancc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anc\ancc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anc\ancc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\anpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\anpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\anpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\anps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\anps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\anp\anps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\basc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\basc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\basc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\bass\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\bass\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bas\bass\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\bcsc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\bcsc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\bcsc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\bcss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\bcss\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bcs\bcss\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\blpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\blpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\blpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\blps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\blps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\blp\blps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\bmsc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\bmsc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\bmsc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\bmss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\bmss\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\bms\bmss\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\cppc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\cppc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\cppc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\cpps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\cpps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cpp\cpps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\cscpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\cscpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\cscpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\cscps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\cscps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cscp\cscps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\ctsc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\ctsc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\ctsc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\ctss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\ctss\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\cts\ctss\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\custom\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\custom\custs\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\custom\custs\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\custom\custs\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\disc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\disc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\disc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\diss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\diss\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\dis\diss\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\findl\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\findl\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\findl\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\findt\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\findt\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\find\findt\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\gatt\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\gatt\gatt_client\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\gatt\gatt_client\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\gatt\gatt_client\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\glpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\glpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\glpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\glps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\glps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\glp\glps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogpbh\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogpbh\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogpbh\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogpd\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogpd\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogpd\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogprh\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogprh\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hogp\hogprh\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\hrpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\hrpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\hrpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\hrps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\hrps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\hrp\hrps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\htpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\htpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\htpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\htpt\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\htpt\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\htp\htpt\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\lanc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\lanc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\lanc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\lans\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\lans\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\lan\lans\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\paspc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\paspc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\paspc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\pasps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\pasps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\pasp\pasps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\proxm\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\proxm\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\proxm\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\proxr\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\proxr\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\prox\proxr\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\rscpc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\rscpc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\rscpc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\rscps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\rscps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\rscp\rscps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\scppc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\scppc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\scppc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\scpps\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\scpps\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\scpp\scpps\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\suota\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\suota\suotar\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\suota\suotar\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\suota\suotar\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\tipc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\tipc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\tipc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\tips\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\tips\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\tip\tips\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\udsc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\udsc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\udsc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\udss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\udss\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\uds\udss\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\wssc\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\wssc\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\wssc\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\wsss\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\wsss\api\;C:\SDK\6.0.12.1015\sdk\ble_stack\profiles\wss\wsss\src\;C:\SDK\6.0.12.1015\sdk\ble_stack\rwble\;C:\SDK\6.0.12.1015\sdk\ble_stack\rwble_hl\;C:\SDK\6.0.12.1015\sdk\common_project_files\;C:\SDK\6.0.12.1015\sdk\common_project_files\ldscripts\;C:\SDK\6.0.12.1015\sdk\common_project_files\misc\;C:\SDK\6.0.12.1015\sdk\common_project_files\scatterfiles\;C:\SDK\6.0.12.1015\sdk\platform\;C:\SDK\6.0.12.1015\sdk\platform\arch\;C:\SDK\6.0.12.1015\sdk\platform\arch\boot\;C:\SDK\6.0.12.1015\sdk\platform\arch\boot\ARM\;C:\SDK\6.0.12.1015\sdk\platform\arch\boot\GCC\;C:\SDK\6.0.12.1015\sdk\platform\arch\compiler\;C:\SDK\6.0.12.1015\sdk\platform\arch\compiler\ARM\;C:\SDK\6.0.12.1015\sdk\platform\arch\compiler\GCC\;C:\SDK\6.0.12.1015\sdk\platform\arch\ll\;C:\SDK\6.0.12.1015\sdk\platform\arch\main\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\arch_console\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\common\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\common\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\crypto\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\dbg\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\dbg\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\gtl\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\gtl\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\gtl\src\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\h4tl\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\h4tl\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\ke\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\ke\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\ke\src\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\nvds\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\nvds\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\nvds\src\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\rf\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\rf\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\rf\src\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\rwip\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\rwip\api\;C:\SDK\6.0.12.1015\sdk\platform\core_modules\rwip\src\;C:\SDK\6.0.12.1015\sdk\platform\driver\;C:\SDK\6.0.12.1015\sdk\platform\driver\adc\;C:\SDK\6.0.12.1015\sdk\platform\driver\battery\;C:\SDK\6.0.12.1015\sdk\platform\driver\ble\;C:\SDK\6.0.12.1015\sdk\platform\driver\dma\;C:\SDK\6.0.12.1015\sdk\platform\driver\gpio\;C:\SDK\6.0.12.1015\sdk\platform\driver\hw_otpc\;C:\SDK\6.0.12.1015\sdk\platform\driver\i2c\;C:\SDK\6.0.12.1015\sdk\platform\driver\i2c_eeprom\;C:\SDK\6.0.12.1015\sdk\platform\driver\pdm\;C:\SDK\6.0.12.1015\sdk\platform\driver\reg\;C:\SDK\6.0.12.1015\sdk\platform\driver\rtc\;C:\SDK\6.0.12.1015\sdk\platform\driver\spi\;C:\SDK\6.0.12.1015\sdk\platform\driver\spi_flash\;C:\SDK\6.0.12.1015\sdk\platform\driver\syscntl\;C:\SDK\6.0.12.1015\sdk\platform\driver\systick\;C:\SDK\6.0.12.1015\sdk\platform\driver\timer\;C:\SDK\6.0.12.1015\sdk\platform\driver\trng\;C:\SDK\6.0.12.1015\sdk\platform\driver\uart\;C:\SDK\6.0.12.1015\sdk\platform\driver\wkupct_quadec\;C:\SDK\6.0.12.1015\sdk\platform\include\;C:\SDK\6.0.12.1015\sdk\platform\system_library\;C:\SDK\6.0.12.1015\sdk\platform\system_library\include\;C:\SDK\6.0.12.1015\sdk\platform\system_library\output\;C:\SDK\6.0.12.1015\sdk\platform\system_library\output\Keil_5\;C:\SDK\6.0.12.1015\sdk\platform\utilities\;C:\SDK\6.0.12.1015\sdk\platform\utilities\otp_cs\;C:\SDK\6.0.12.1015\sdk\platform\utilities\otp_hdr\;C:\SDK\6.0.12.1015\third_party\;C:\SDK\6.0.12.1015\third_party\crc32\;C:\SDK\6.0.12.1015\third_party\hash\;C:\SDK\6.0.12.1015\third_party\irng\;C:\SDK\6.0.12.1015\third_party\micro_ecc\;C:\SDK\6.0.12.1015\third_party\rand\;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: C:\SDK\6.0.12.1015\projects\target_apps\peripheral_examples\shared\peripheral_examples.sct
  group sdk_boot
    C:/SDK/6.0.12.1015/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/SDK/6.0.12.1015/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/SDK/6.0.12.1015/projects/target_apps/peripheral_examples/shared/source/: exceptions.c
  group sdk_driver
    C:/SDK/6.0.12.1015/sdk/platform/driver/syscntl/: syscntl.c
    C:/SDK/6.0.12.1015/sdk/platform/driver/gpio/: gpio.c
    C:/SDK/6.0.12.1015/sdk/platform/driver/uart/: uart.c uart_utils.c
    C:/SDK/6.0.12.1015/sdk/platform/driver/timer/: timer0.c timer1.c
    C:/SDK/6.0.12.1015/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/SDK/6.0.12.1015/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/SDK/6.0.12.1015/sdk/platform/driver/spi/: spi_58x.c
    C:/SDK/6.0.12.1015/sdk/platform/driver/spi_flash/: spi_flash.c
  group user_app
    ../src/: main.c user_periph_setup.c user_timer1.c
    C:/SDK/6.0.12.1015/sdk/platform/arch/main/: arch_system.c
