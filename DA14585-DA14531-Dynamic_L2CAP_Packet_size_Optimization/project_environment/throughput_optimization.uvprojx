# Keil uVision project throughput_optimization.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: tput_optimization_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14585__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_ancc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bass;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bcss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bmss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bond_db;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_common;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_ctsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_ctss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_custs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_default_hnd;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_diss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_easy;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_entry;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_findme;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_gattc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_proxr;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_sec;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_suotar;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_udss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_wsss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\em;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\llc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\lld;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\llm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\ea;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\ea\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\em;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\em\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\hci;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\hci\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\hci\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att\attc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att\attm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att\atts;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gap;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gap\gapc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gap\gapm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gatt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gatt\gattc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gatt\gattm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\l2c;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\l2c\l2cc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\l2c\l2cm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\smp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\smp\smpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\smp\smpm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc\ancc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc\ancc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc\ancc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\basc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\basc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\basc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\bass;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\bass\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\bass\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cppc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cppc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cppc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cpps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cpps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cpps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom\custs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom\custs\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom\custs\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\disc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\disc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\disc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\diss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\diss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\diss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findl\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findl\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findt\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findt\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt\gatt_client;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpbh;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpd;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpd\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpd\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogprh;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogprh\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogprh\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpt\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpt\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lanc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lanc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lanc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lans;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lans\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lans\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\paspc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\paspc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\paspc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\pasps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\pasps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\pasps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxm\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxm\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxr;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxr\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxr\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scppc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scppc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scppc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scpps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scpps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scpps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota\suotar;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota\suotar\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota\suotar\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tipc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tipc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tipc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tips;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tips\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tips\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wssc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wssc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wssc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wsss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wsss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wsss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\rwble;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\rwble_hl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\ldscripts;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\misc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\scatterfiles;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\boot;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\boot\ARM;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\boot\GCC;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\compiler;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\compiler\ARM;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\compiler\GCC;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\ll;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\main;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\arch_console;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\common;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\common\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\crypto;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\dbg;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\dbg\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\gtl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\gtl\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\gtl\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\h4tl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\h4tl\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\ke;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\ke\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\ke\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\nvds;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\nvds\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\nvds\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rf;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rf\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rf\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rwip;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rwip\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rwip\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\adc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\battery;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\ble;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\dma;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\gpio;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\hw_otpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\i2c;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\i2c_eeprom;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\pdm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\reg;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\rtc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\spi;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\spi_flash;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\syscntl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\systick;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\timer;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\trng;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\uart;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\wkupct_quadec;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\include;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library\include;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library\output;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library\output\Keil_5;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\utilities;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\utilities\otp_cs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\utilities\otp_hdr;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\crc32;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\hash;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\irng;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\micro_ecc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=empty_peripheral_template_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/third_party/rand/: chacha20.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/third_party/hash/: hash.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/syscntl/: syscntl.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/gpio/: gpio.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/battery/: battery.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/trng/: trng.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/systick/: systick.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/uart/: uart.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/dma/: dma.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/driver/i2c/: i2c.c
  group sdk_ble
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/rwble/: rwble.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/bas/basc/src/: basc.c basc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/blp/blpc/src/: blpc.c blpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/blp/blps/src/: blps.c blps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/find/findt/src/: findt.c findt_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/htp/htpc/src/: htpc.c htpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/htp/htpt/src/: htpt.c htpt_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/anp/anpc/src/: anpc.c anpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/anp/anps/src/: anps.c anps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/glp/glpc/src/: glpc.c glpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/glp/glps/src/: glps.c glps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/tip/tipc/src/: tipc.c tipc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/tip/tips/src/: tips.c tips_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/find/findl/src/: findl.c findl_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/lan/lanc/src/: lanc.c lanc_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/lan/lans/src/: lans.c lans_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/custom/: custom_common.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/DA14531/SDKs/6.0.12.1020.2_L2CAP_opt_port/SDK/6.0.12.1020.2/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_throughput_opt.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: simple_beacon_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=empty_peripheral_template_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: tput_optimization_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_ancc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bass;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bcss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bmss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_bond_db;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_common;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_ctsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_ctss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_custs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_default_hnd;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_diss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_easy;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_entry;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_findme;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_gattc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_proxr;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_sec;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_suotar;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_udss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\app_modules\src\app_wsss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\em;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\llc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\lld;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\controller\llm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\ea;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\ea\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\em;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\em\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\hci;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\hci\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\hci\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att\attc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att\attm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\att\atts;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gap;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gap\gapc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gap\gapm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gatt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gatt\gattc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\gatt\gattm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\l2c;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\l2c\l2cc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\l2c\l2cm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\smp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\smp\smpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\host\smp\smpm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc\ancc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc\ancc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anc\ancc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\anp\anps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\basc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\basc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\basc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\bass;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\bass\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bas\bass\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bcs\bcss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\blp\blps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\bms\bmss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cppc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cppc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cppc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cpps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cpps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cpp\cpps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cscp\cscps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\cts\ctss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom\custs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom\custs\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\custom\custs\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\disc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\disc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\disc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\diss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\diss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\dis\diss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findl\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findl\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findt\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\find\findt\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt\gatt_client;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\glp\glps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpbh;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpd;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpd\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogpd\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogprh;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogprh\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hogp\hogprh\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\hrp\hrps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpt;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpt\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\htp\htpt\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lanc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lanc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lanc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lans;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lans\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\lan\lans\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\paspc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\paspc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\paspc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\pasps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\pasps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\pasp\pasps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxm\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxm\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxr;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxr\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\prox\proxr\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscpc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscpc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\rscp\rscps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scppc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scppc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scppc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scpps;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scpps\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\scpp\scpps\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota\suotar;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota\suotar\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\suota\suotar\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tipc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tipc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tipc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tips;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tips\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\tip\tips\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udsc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udsc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udsc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\uds\udss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wssc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wssc\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wssc\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wsss;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wsss\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\profiles\wss\wsss\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\rwble;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\ble_stack\rwble_hl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\ldscripts;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\misc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\scatterfiles;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\boot;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\boot\ARM;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\boot\GCC;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\compiler;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\compiler\ARM;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\compiler\GCC;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\ll;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\arch\main;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\arch_console;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\common;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\common\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\crypto;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\dbg;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\dbg\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\gtl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\gtl\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\gtl\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\h4tl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\h4tl\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\ke;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\ke\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\ke\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\nvds;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\nvds\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\nvds\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rf;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rf\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rf\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rwip;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rwip\api;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\core_modules\rwip\src;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\adc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\battery;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\ble;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\dma;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\gpio;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\hw_otpc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\i2c;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\i2c_eeprom;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\pdm;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\reg;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\rtc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\spi;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\spi_flash;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\syscntl;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\systick;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\timer;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\trng;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\uart;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\driver\wkupct_quadec;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\include;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library\include;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library\output;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\system_library\output\Keil_5;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\utilities;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\utilities\otp_cs;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\platform\utilities\otp_hdr;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\crc32;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\hash;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\irng;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\micro_ecc;C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\third_party\rand
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\DA14531\SDKs\6.0.12.1020.2_L2CAP_opt_port\SDK\6.0.12.1020.2\sdk\common_project_files\misc\da14531_symbols.txt  --symdefs=empty_peripheral_template_531_symdef.txt --any_placement=best_fit --datacompressor off
