# Keil uVision project Capacitative_sensor.uvprojx, settings and files
target ble_app_peripheral_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_peripheral_585 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: .\..\;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\include;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_custs;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_diss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_findme;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_suotar;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\em;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\lld;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\ea\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\em\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\atts;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\hci\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble_hl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\common_project_files;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\boot\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\ll\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\main;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\arch_console;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\common\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\crypto;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rf\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\adc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\battery;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\ble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\gpio;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\hw_otpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\reg;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_flash;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_hci;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\syscntl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\systick;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\trng;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\uart;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\dma;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\pdm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\rand;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\hash;..\src\user_driver;..\src\i2c
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_585.txt" C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=ble_app_peripheral_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/system_library/output/Keil_5/: system_library.lib
    C:/Users/nilmer/Documents/SDK6.0.10.511//third_party/rand/: chacha20.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//third_party/hash/: hash.c
  group sdk_driver
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/syscntl/: syscntl.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/gpio/: gpio.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/battery/: battery.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/adc/: adc.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/trng/: trng.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/spi/: spi.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/uart/: uart2.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/hw_otpc/: hw_otpc.c
  group sdk_ble
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/ble_stack/rwble/: rwble.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/core_modules/rwip/src/: rwip.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/core_modules/rf/src/: rf_585.c
  group sdk_profiles
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/ble_stack/profiles/: prf_utils.c prf.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/ble_stack/profiles/custom/: custom_common.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
  group sdk_app
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group sdk_driver_api
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/adc/: adc.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/battery/: battery.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/gpio/: gpio.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/spi/: spi.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/spi_flash/: spi_flash.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/systick/: systick.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/trng/: trng.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/uart/: uart.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/arch/: arch_api.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/arch/main/: arch_wdg.h
    C:/Users/nilmer/Documents/SDK6.0.10.511//sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c Capacitative_sensor.c
  group user_driver
    ../src/user_driver/: fdc2x1x.c
    ../src/i2c/: i2c.c
target ble_app_peripheral_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: ble_app_peripheral_586 +hex
  c flags: Optim=4 wLevel=2
  c define: __DA14586__
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: .\..\;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\include;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_custs;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_diss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_findme;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_suotar;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\em;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\lld;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\ea\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\em\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\atts;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\hci\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble_hl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\common_project_files;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\boot\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\ll\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\main;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\arch_console;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\common\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\crypto;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rf\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\adc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\battery;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\ble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\gpio;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\hw_otpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\reg;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_flash;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_hci;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\syscntl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\systick;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\trng;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\uart;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\dma;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\pdm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\rand;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\hash;.\..\;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\include;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_custs;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_diss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_findme;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_suotar;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\em;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\lld;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\ea\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\em\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\atts;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\hci\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble_hl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\common_project_files;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\boot\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\ll\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\main;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\arch_console;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\common\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\crypto;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rf\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\adc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\battery;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\ble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\gpio;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\hw_otpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\reg;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_flash;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_hci;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\syscntl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\systick;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\trng;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\uart;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\dma;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\pdm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\rand;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\hash;.\..\;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\include;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_custs;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_diss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_findme;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\app_modules\src\app_suotar;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\em;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\lld;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\controller\llm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\ea\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\em\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\attm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\att\atts;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\host\smp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\anp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\blp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\disc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\find\findt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\glp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\htp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\lan;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\tip;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\uds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\hci\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\ble_stack\rwble_hl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\common_project_files;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\boot\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\ll\rvds;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch\main;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\arch;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\arch_console;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\common\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\crypto;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\ke\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rf\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\adc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\battery;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\ble;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\gpio;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\hw_otpc;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\reg;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_flash;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\spi_hci;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\syscntl;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\systick;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\trng;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\uart;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\rand;C:\Users\nilmer\Documents\SDK6.0.10.511\\third_party\hash;..\src\i2c;..\src\user_driver
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_586.txt" C:\Users\nilmer\Documents\SDK6.0.10.511\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=ble_app_peripheral_symdef.txt --any_placement=best_fit --datacompressor off
