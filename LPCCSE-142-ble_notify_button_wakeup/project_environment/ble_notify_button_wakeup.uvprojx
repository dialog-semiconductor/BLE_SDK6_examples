# Keil uVision project ble_notify_button_wakeup.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: lego_rcu_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: C:\Users\ttsakiri\Documents\LPCCSE-142-ble_notify_button_wakeup\src\;C:\Users\ttsakiri\Documents\LPCCSE-142-ble_notify_button_wakeup\src\custom_profile\;C:\Users\ttsakiri\Documents\LPCCSE-142-ble_notify_button_wakeup\src\config\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_ancc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bass\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bcss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bmss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bond_db\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_common\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_ctsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_ctss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_custs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_default_hnd\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_diss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_easy\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_entry\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_findme\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_gattc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_proxr\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_sec\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_suotar\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_udss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_wsss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\em\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\llc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\lld\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\llm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\ea\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\ea\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\em\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\em\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\hci\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\hci\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\hci\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\attc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\attm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\atts\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gap\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gap\gapc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gap\gapm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gatt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gatt\gattc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gatt\gattm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\l2c\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\l2c\l2cc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\l2c\l2cm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\smp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\smp\smpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\smp\smpm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\ancc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\ancc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\ancc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\basc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\basc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\basc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\bass\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\bass\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\bass\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cppc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cppc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cppc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cpps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cpps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cpps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\custs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\custs\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\custs\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\disc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\disc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\disc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\diss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\diss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\diss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findl\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findl\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findt\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findt\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\gatt_client\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\gatt_client\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\gatt_client\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpbh\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpbh\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpbh\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpd\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpd\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpd\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogprh\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogprh\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogprh\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpt\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpt\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lanc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lanc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lanc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lans\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lans\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lans\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\paspc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\paspc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\paspc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\pasps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\pasps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\pasps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxm\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxm\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxr\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxr\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxr\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scppc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scppc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scppc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scpps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scpps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scpps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\suotar\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\suotar\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\suotar\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tipc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tipc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tipc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tips\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tips\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tips\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wssc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wssc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wssc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wsss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wsss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wsss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\rwble\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\rwble_hl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\ldscripts\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\misc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\scatterfiles\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\boot\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\boot\ARM\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\boot\GCC\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\compiler\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\compiler\ARM\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\compiler\GCC\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\ll\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\main\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\arch_console\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\common\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\common\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\crypto\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\dbg\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\dbg\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\gtl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\gtl\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\gtl\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\h4tl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\h4tl\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\ke\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\ke\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\ke\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\nvds\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\nvds\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\nvds\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rf\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rf\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rf\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rwip\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rwip\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rwip\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\adc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\battery\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\ble\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\dma\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\gpio\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\hw_otpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\i2c\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\i2c_eeprom\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\pdm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\reg\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\rtc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\spi\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\spi_flash\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\syscntl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\systick\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\timer\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\trng\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\uart\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\wkupct_quadec\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\include\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\include\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\output\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\output\Keil_5\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\utilities\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\utilities\otp_cs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\utilities\otp_hdr\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\crc32\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\hash\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\irng\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\micro_ecc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\rand\;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\misc\da14585_symbols.txt                                                                         --symdefs=lego_rcu_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/third_party/rand/: chacha20.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/third_party/hash/: hash.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531_es2.lib
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/syscntl/: syscntl.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/gpio/: gpio.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/battery/: battery.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/trng/: trng.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/systick/: systick.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/uart/: uart.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/dma/: dma.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/driver/i2c/: i2c.c
  group sdk_ble
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/rwble/: rwble.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/bas/basc/src/: basc.c basc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/blp/blpc/src/: blpc.c blpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/blp/blps/src/: blps.c blps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/find/findt/src/: findt.c findt_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/htp/htpc/src/: htpc.c htpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/htp/htpt/src/: htpt.c htpt_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/anp/anpc/src/: anpc.c anpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/anp/anps/src/: anps.c anps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/glp/glpc/src/: glpc.c glpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/glp/glps/src/: glps.c glps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/tip/tipc/src/: tipc.c tipc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/tip/tips/src/: tips.c tips_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/find/findl/src/: findl.c findl_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/lan/lanc/src/: lanc.c lanc_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/lan/lans/src/: lans.c lans_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/custom/: custom_common.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/sdks/SDK_6.0.11.1002/SDK/6.0.11.1002/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: ble_notify_button_wakeup.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: lego_rcu_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\misc\da14585_symbols.txt                                                                         --symdefs=lego_rcu_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_notify_button_wakeup +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__ __ES2_DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: C:\Users\ttsakiri\Documents\LPCCSE-142-ble_notify_button_wakeup\src\;C:\Users\ttsakiri\Documents\LPCCSE-142-ble_notify_button_wakeup\src\custom_profile\;C:\Users\ttsakiri\Documents\LPCCSE-142-ble_notify_button_wakeup\src\config\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_ancc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bass\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bcss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bmss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_bond_db\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_common\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_ctsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_ctss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_custs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_default_hnd\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_diss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_easy\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_entry\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_findme\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_gattc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_proxr\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_sec\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_suotar\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_udss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\app_modules\src\app_wsss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\em\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\llc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\lld\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\controller\llm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\ea\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\ea\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\em\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\em\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\hci\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\hci\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\hci\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\attc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\attm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\att\atts\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gap\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gap\gapc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gap\gapm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gatt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gatt\gattc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\gatt\gattm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\l2c\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\l2c\l2cc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\l2c\l2cm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\smp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\smp\smpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\host\smp\smpm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\ancc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\ancc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anc\ancc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\anp\anps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\basc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\basc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\basc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\bass\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\bass\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bas\bass\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bcs\bcss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\blp\blps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\bms\bmss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cppc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cppc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cppc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cpps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cpps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cpp\cpps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cscp\cscps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\cts\ctss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\custs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\custs\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\custom\custs\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\disc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\disc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\disc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\diss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\diss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\dis\diss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findl\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findl\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findt\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\find\findt\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\gatt_client\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\gatt_client\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\gatt\gatt_client\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\glp\glps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpbh\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpbh\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpbh\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpd\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpd\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogpd\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogprh\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogprh\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hogp\hogprh\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\hrp\hrps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpt\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpt\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\htp\htpt\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lanc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lanc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lanc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lans\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lans\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\lan\lans\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\paspc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\paspc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\paspc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\pasps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\pasps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\pasp\pasps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxm\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxm\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxr\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxr\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\prox\proxr\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscpc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscpc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\rscp\rscps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scppc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scppc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scppc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scpps\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scpps\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\scpp\scpps\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\suotar\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\suotar\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\suota\suotar\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tipc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tipc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tipc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tips\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tips\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\tip\tips\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udsc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udsc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udsc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\uds\udss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wssc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wssc\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wssc\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wsss\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wsss\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\profiles\wss\wsss\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\rwble\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\ble_stack\rwble_hl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\ldscripts\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\misc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\scatterfiles\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\boot\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\boot\ARM\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\boot\GCC\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\compiler\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\compiler\ARM\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\compiler\GCC\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\ll\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\arch\main\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\arch_console\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\common\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\common\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\crypto\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\dbg\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\dbg\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\gtl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\gtl\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\gtl\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\h4tl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\h4tl\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\ke\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\ke\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\ke\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\nvds\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\nvds\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\nvds\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rf\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rf\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rf\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rwip\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rwip\api\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\core_modules\rwip\src\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\adc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\battery\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\ble\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\dma\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\gpio\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\hw_otpc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\i2c\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\i2c_eeprom\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\pdm\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\reg\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\rtc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\spi\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\spi_flash\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\syscntl\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\systick\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\timer\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\trng\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\uart\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\driver\wkupct_quadec\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\include\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\include\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\output\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\system_library\output\Keil_5\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\utilities\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\utilities\otp_cs\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\platform\utilities\otp_hdr\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\crc32\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\hash\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\irng\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\micro_ecc\;C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\third_party\rand\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\sdks\SDK_6.0.11.1002\SDK\6.0.11.1002\sdk\common_project_files\misc\da14531_symbols_es2.txt   --symdefs=lego_rcu_531_symdef.txt --any_placement=best_fit --datacompressor off
