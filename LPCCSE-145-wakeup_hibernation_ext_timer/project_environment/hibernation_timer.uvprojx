# Keil uVision project hibernation_timer.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: hibernation_timer_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h  --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;..\src\platform;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_ancc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bass;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bcss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bmss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bond_db;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_common;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_ctsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_ctss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_custs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_default_hnd;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_diss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_easy;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_entry;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_findme;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_gattc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_proxr;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_sec;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_suotar;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_udss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_wsss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\em;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\llc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\lld;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\llm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\ea;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\ea\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\em;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\em\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\hci;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\hci\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\hci\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att\attc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att\attm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att\atts;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gap;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gatt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\l2c;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\smp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\rwble;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\rwble_hl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\ldscripts;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\misc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\scatterfiles;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\boot;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\boot\ARM;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\boot\GCC;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\compiler;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\compiler\ARM;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\compiler\GCC;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\ll;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\main;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\arch_console;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\common;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\common\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\crypto;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\dbg;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\dbg\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\gtl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\ke;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\ke\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\ke\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\nvds;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rf;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rf\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rf\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rwip;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\adc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\battery;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\ble;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\dma;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\gpio;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\hw_otpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\i2c;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\i2c_eeprom;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\pdm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\reg;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\rtc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\spi;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\spi_flash;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\syscntl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\systick;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\timer;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\trng;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\uart;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\wkupct_quadec;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\include;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library\include;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library\output;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library\output\Keil_5;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\utilities;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\utilities\otp_cs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\utilities\otp_hdr;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\crc32;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\hash;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\irng;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\micro_ecc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\rand
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_531.txt" C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\misc\da14531_symbols.txt --symdefs=ble_app_barebone_531_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/third_party/hash/: hash.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/syscntl/: syscntl.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/gpio/: gpio.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/battery/: battery.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/trng/: trng.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/dma/: dma.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/driver/rtc/: rtc.c
  group sdk_ble
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/ble_stack/rwble/: rwble.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/app_modules/src/app_easy/: app_easy_timer.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/sdks/6.0.12.1020GA/SDK_6.0.12.1020/SDK/6.0.12.1020/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_hibernation_timer.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: hibernation_timer_531 +hex
  AfterMake: as above
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: as above
  c include: ..\src;..\src\config;..\src\platform;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_ancc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bass;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bcss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bmss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_bond_db;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_common;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_ctsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_ctss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_custs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_default_hnd;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_diss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_easy;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_entry;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_findme;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_gattc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_proxr;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_sec;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_suotar;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_udss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\app_modules\src\app_wsss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\em;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\llc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\lld;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\controller\llm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\ea;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\ea\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\em;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\em\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\hci;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\hci\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\hci\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att\attc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att\attm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\att\atts;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gap;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gatt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\l2c;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\smp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\rwble;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\ble_stack\rwble_hl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\ldscripts;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\misc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\common_project_files\scatterfiles;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\boot;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\boot\ARM;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\boot\GCC;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\compiler;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\compiler\ARM;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\compiler\GCC;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\ll;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\arch\main;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\arch_console;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\common;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\common\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\crypto;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\dbg;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\dbg\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\gtl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\ke;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\ke\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\ke\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\nvds;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rf;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rf\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rf\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rwip;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\api;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\src;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\adc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\battery;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\ble;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\dma;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\gpio;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\hw_otpc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\i2c;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\i2c_eeprom;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\pdm;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\reg;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\rtc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\spi;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\spi_flash;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\syscntl;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\systick;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\timer;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\trng;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\uart;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\driver\wkupct_quadec;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\include;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library\include;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library\output;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\system_library\output\Keil_5;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\utilities;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\utilities\otp_cs;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\sdk\platform\utilities\otp_hdr;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\crc32;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\hash;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\irng;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\micro_ecc;C:\sdks\6.0.12.1020GA\SDK_6.0.12.1020\SDK\6.0.12.1020\third_party\rand;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: as above
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: hibernation_timer_531 +hex
  AfterMake: as above
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: as above
