# Keil uVision project empty_peripheral_template.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: empty_peripheral_template_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ancc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bass;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bcss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bmss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bond_db;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_common;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ctsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ctss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_custs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_default_hnd;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_diss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_easy;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_entry;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_findme;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_gattc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_proxr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_sec;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_suotar;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_udss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_wsss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\em;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\llc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\lld;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\llm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\ea;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\ea\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\em;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\em\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\attc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\attm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\atts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap\gapc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap\gapm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt\gattc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt\gattm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c\l2cc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c\l2cm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp\smpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp\smpm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\rwble;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\rwble_hl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\ldscripts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\misc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\scatterfiles;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\ARM;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\GCC;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\ARM;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\GCC;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\ll;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\main;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\arch_console;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\common;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\common\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\crypto;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\dbg;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\dbg\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\h4tl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\h4tl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\adc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\battery;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\ble;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\dma;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\gpio;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\hw_otpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\i2c;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\i2c_eeprom;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\pdm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\reg;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\rtc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\spi;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\spi_flash;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\syscntl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\systick;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\timer;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\trng;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\uart;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wifi;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wkupct_quadec;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0\Include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output\Keil_5;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities\otp_cs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities\otp_hdr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\crc32;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\hash;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\irng;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\micro_ecc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\rand
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=empty_peripheral_template_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_hibernation.c arch_rom.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/third_party/rand/: chacha20.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/third_party/hash/: hash.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/syscntl/: syscntl.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/gpio/: gpio.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/battery/: battery.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/trng/: trng.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/systick/: systick.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/uart/: uart.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/dma/: dma.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/driver/i2c/: i2c.c
    ../../../DA145xx_SDK/6.0.14.1114/sdk/platform/driver/wifi/: wlan_coex.c
  group sdk_ble
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/rwble/: rwble.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/bas/basc/src/: basc.c basc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/blp/blpc/src/: blpc.c blpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/blp/blps/src/: blps.c blps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/find/findt/src/: findt.c findt_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/htp/htpc/src/: htpc.c htpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/htp/htpt/src/: htpt.c htpt_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/anp/anpc/src/: anpc.c anpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/anp/anps/src/: anps.c anps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/glp/glpc/src/: glpc.c glpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/glp/glps/src/: glps.c glps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/tip/tipc/src/: tipc.c tipc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/tip/tips/src/: tips.c tips_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/find/findl/src/: findl.c findl_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/lan/lanc/src/: lanc.c lanc_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/lan/lans/src/: lans.c lans_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/custom/: custom_common.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c app_easy_whitelist.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/Users/mtzanida/Desktop/GITREP~1/WiFi_Coexistance_example/DA145xx_SDK/6.0.14.1114/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ./../src/: user_empty_peripheral_template.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: empty_peripheral_template_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ancc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bass;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bcss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bmss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bond_db;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_common;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ctsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ctss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_custs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_default_hnd;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_diss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_easy;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_entry;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_findme;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_gattc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_proxr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_sec;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_suotar;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_udss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_wsss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\em;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\llc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\lld;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\llm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\ea;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\ea\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\em;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\em\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\attc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\attm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\atts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap\gapc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap\gapm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt\gattc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt\gattm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c\l2cc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c\l2cm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp\smpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp\smpm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\rwble;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\rwble_hl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\ldscripts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\misc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\scatterfiles;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\ARM;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\GCC;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\ARM;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\GCC;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\ll;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\main;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\arch_console;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\common;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\common\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\crypto;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\dbg;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\dbg\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\h4tl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\h4tl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\adc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\battery;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\ble;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\dma;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\gpio;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\hw_otpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\i2c;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\i2c_eeprom;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\pdm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\reg;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\rtc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\spi;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\spi_flash;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\syscntl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\systick;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\timer;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\trng;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\uart;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wifi;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wkupct_quadec;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0\Include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output\Keil_5;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities\otp_cs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities\otp_hdr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\crc32;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\hash;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\irng;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\micro_ecc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=empty_peripheral_template_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: empty_peripheral_template_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ancc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bass;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bcss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bmss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_bond_db;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_common;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ctsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_ctss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_custs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_default_hnd;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_diss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_easy;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_entry;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_findme;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_gattc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_proxr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_sec;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_suotar;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_udss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\app_modules\src\app_wsss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\em;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\llc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\lld;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\controller\llm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\ea;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\ea\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\em;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\em\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\hci\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\attc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\attm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\att\atts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap\gapc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gap\gapm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt\gattc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\gatt\gattm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c\l2cc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\l2c\l2cm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp\smpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\host\smp\smpm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findl\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\find\findt\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\rwble;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\ble_stack\rwble_hl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\ldscripts;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\misc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\scatterfiles;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\ARM;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\GCC;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\boot\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\ARM;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\GCC;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\compiler\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\ll;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\arch\main;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\arch_console;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\common;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\common\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\crypto;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\dbg;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\dbg\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\gtl\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\h4tl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\h4tl\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\ke\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\nvds\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rf\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip\api;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\core_modules\rwip\src;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\adc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\battery;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\ble;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\dma;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\gpio;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\hw_otpc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\i2c;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\i2c_eeprom;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\pdm;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\reg;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\rtc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\spi;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\spi_flash;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\syscntl;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\systick;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\timer;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\trng;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\uart;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wifi;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wkupct_quadec;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0\Include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\include;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output\IAR;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\system_library\output\Keil_5;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities\otp_cs;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\platform\utilities\otp_hdr;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\crc32;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\hash;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\irng;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\micro_ecc;C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\third_party\rand;..\..\..\DA145xx_SDK\6.0.14.1114\sdk\platform\driver\wifi
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\Users\mtzanida\Desktop\GITREP~1\WiFi_Coexistance_example\DA145xx_SDK\6.0.14.1114\sdk\common_project_files\misc\da14531_symbols.txt --symdefs=empty_peripheral_template_531_symdef.txt --any_placement=best_fit --datacompressor off
