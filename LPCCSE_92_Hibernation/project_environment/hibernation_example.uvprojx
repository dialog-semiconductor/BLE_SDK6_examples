# Keil uVision project hibernation_example.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: prox_reporter_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_ancc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bass;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bcss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bmss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bond_db;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_common;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_ctsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_ctss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_custs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_default_hnd;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_diss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_easy;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_entry;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_findme;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_gattc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_proxr;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_sec;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_suotar;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_udss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_wsss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\em;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\llc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\lld;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\llm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\ea;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\ea\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\em;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\em\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\hci;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\hci\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\hci\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att\attc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att\attm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att\atts;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gap;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gatt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\l2c;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\smp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\rwble;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\rwble_hl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\ldscripts;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\misc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\scatterfiles;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\boot;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\boot\ARM;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\boot\GCC;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\compiler;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\compiler\ARM;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\compiler\GCC;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\ll;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\main;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\arch_console;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\common;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\common\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\crypto;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\dbg;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\dbg\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\gtl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\ke;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\ke\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\ke\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\nvds;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rf;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rf\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rf\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rwip;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\adc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\battery;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\ble;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\dma;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\gpio;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\hw_otpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\i2c;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\i2c_eeprom;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\pdm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\reg;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\rtc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\spi;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\spi_flash;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\syscntl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\systick;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\timer;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\trng;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\uart;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\wkupct_quadec;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\include;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library\include;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library\output;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library\output\Keil_5;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\utilities;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\utilities\otp_cs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\utilities\otp_hdr;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\crc32;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\hash;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\irng;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\micro_ecc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=prox_reporter_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/third_party/rand/: chacha20.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/third_party/hash/: hash.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/syscntl/: syscntl.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/gpio/: gpio.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/battery/: battery.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/dma/: dma.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/uart/: uart.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/i2c/: i2c.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/trng/: trng.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/rtc/: rtc.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/driver/timer/: timer1.c
  group sdk_ble
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/ble_stack/rwble/: rwble.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/ble_stack/profiles/: prf.c prf_utils.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
  group sdk_app
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Workspace/SDKs/SDK_6.0.12.1020_fresh/SDK/6.0.12.1020/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_hibernation.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: prox_reporter_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=prox_reporter_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: prox_reporter_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_ancc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bass;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bcss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bmss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_bond_db;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_common;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_ctsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_ctss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_custs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_default_hnd;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_diss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_easy;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_entry;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_findme;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_gattc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_proxr;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_sec;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_suotar;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_udss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\app_modules\src\app_wsss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\em;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\llc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\lld;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\controller\llm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\ea;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\ea\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\em;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\em\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\hci;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\hci\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\hci\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att\attc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att\attm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\att\atts;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gap;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gap\gapm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gatt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\gatt\gattm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\l2c;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\l2c\l2cm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\smp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\host\smp\smpm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findl\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\find\findt\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\rwble;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\ble_stack\rwble_hl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\ldscripts;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\misc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\scatterfiles;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\boot;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\boot\ARM;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\boot\GCC;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\compiler;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\compiler\ARM;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\compiler\GCC;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\ll;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\arch\main;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\arch_console;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\common;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\common\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\crypto;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\dbg;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\dbg\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\gtl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\gtl\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\h4tl\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\ke;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\ke\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\ke\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\nvds;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\nvds\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rf;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rf\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rf\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rwip;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\api;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\core_modules\rwip\src;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\adc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\battery;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\ble;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\dma;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\gpio;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\hw_otpc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\i2c;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\i2c_eeprom;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\pdm;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\reg;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\rtc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\spi;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\spi_flash;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\syscntl;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\systick;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\timer;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\trng;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\uart;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\driver\wkupct_quadec;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\include;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library\include;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library\output;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\system_library\output\Keil_5;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\utilities;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\utilities\otp_cs;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\platform\utilities\otp_hdr;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\crc32;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\hash;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\irng;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\micro_ecc;C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\third_party\rand
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\Workspace\SDKs\SDK_6.0.12.1020_fresh\SDK\6.0.12.1020\sdk\common_project_files\misc\da14531_symbols.txt  --symdefs=prox_reporter_531_symdef.txt --any_placement=best_fit --datacompressor off
