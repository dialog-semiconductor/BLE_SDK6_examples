# Keil uVision project ble_burst_adv.uvprojx, settings and files
target ble_burst_adv_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_burst_adv_585 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\include;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_bass;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_diss;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_proxr;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_suotar;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_findme;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_custs;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\em;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\llc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\lld;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\llm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\attc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\attm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\atts;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap\gapc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap\gapm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt\gattc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt\gattm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\l2c\l2cc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\l2c\l2cm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp\smpc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp\smpm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\bas\bass\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\rwble;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\rwble_hl;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\ea\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\em\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\common_project_files;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\boot\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\compiler\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\ll\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\main;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\arch_console;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\common\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\crypto;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\dbg\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\gtl\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\ke\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\ke\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\nvds\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\rf\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\gtl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\rwip\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\h4tl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\adc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\battery;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\gpio;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\i2c_eeprom;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\reg;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\spi;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\spi_flash;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\syscntl;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\systick;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\trng;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\uart;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\wkupct_quadec;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\ble;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\hw_otpc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\dma;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\pdm;.\..\src\config;.\..\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\system_library\include;..\src\custom_profile;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\lan;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\cpp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\rscp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\pasp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\cscp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\anp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\hrp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\hci\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\hci\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find\findt\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find\findl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\custom;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\third_party\rand;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\third_party\hash
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_585.txt" C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=ble_burst_adv_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/system_library/output/Keil_5/: system_library.lib
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//third_party/rand/: chacha20.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//third_party/hash/: hash.c
  group sdk_driver
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/syscntl/: syscntl.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/gpio/: gpio.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/battery/: battery.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/adc/: adc.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/trng/: trng.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/spi/: spi.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/systick/: systick.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/uart/: uart2.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/hw_otpc/: hw_otpc.c
  group sdk_ble
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/core_modules/rf/src/: rf_585.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/rwble/: rwble.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/bas/basc/src/: basc.c basc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/blp/blpc/src/: blpc.c blpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/blp/blps/src/: blps.c blps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/find/findt/src/: findt.c findt_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/htp/htpc/src/: htpc.c htpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/htp/htpt/src/: htpt.c htpt_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/anp/anpc/src/: anpc.c anpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/anp/anps/src/: anps.c anps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/glp/glpc/src/: glpc.c glpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/glp/glps/src/: glps.c glps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/tip/tipc/src/: tipc.c tipc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/tip/tips/src/: tips.c tips_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/find/findl/src/: findl.c findl_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/lan/lanc/src/: lanc.c lanc_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/lan/lans/src/: lans.c lans_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/custom/: custom_common.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group sdk_driver_api
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/adc/: adc.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/battery/: battery.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/gpio/: gpio.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/spi/: spi.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/spi_flash/: spi_flash.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/systick/: systick.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/trng/: trng.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/uart/: uart.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/arch/main/: arch_wdg.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/arch/: arch_api.h
    C:/Users/imorris/Documents/SDKs/BLE/SDK/DA14585_SDK_6.0.10.511_0_Public//sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_ble_burst_adv.c
target ble_burst_adv_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: ble_burst_adv_586 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\include;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_bass;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_diss;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_proxr;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_suotar;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_findme;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_custs;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\em;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\llc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\lld;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\llm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\attc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\attm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\atts;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap\gapc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap\gapm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt\gattc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt\gattm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\l2c\l2cc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\l2c\l2cm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp\smpc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp\smpm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\bas\bass\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\rwble;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\rwble_hl;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\ea\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\em\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\common_project_files;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\boot\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\compiler\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\ll\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\main;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\arch_console;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\common\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\crypto;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\dbg\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\gtl\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\ke\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\ke\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\nvds\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\rf\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\gtl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\rwip\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\h4tl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\adc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\battery;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\gpio;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\i2c_eeprom;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\reg;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\spi;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\spi_flash;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\syscntl;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\systick;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\trng;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\uart;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\wkupct_quadec;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\ble;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\hw_otpc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\dma;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\pdm;.\..\src\config;.\..\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\system_library\include;..\src\custom_profile;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\lan;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\cpp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\rscp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\pasp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\cscp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\anp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\hrp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\hci\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\hci\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find\findt\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find\findl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\custom;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\third_party\rand;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\third_party\hash;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\include;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_bass;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_diss;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_proxr;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_suotar;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_findme;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\app_modules\src\app_custs;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\em;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\llc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\lld;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\controller\llm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\attc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\attm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\att\atts;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap\gapc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gap\gapm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt\gattc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\gatt\gattm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\l2c\l2cc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\l2c\l2cm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp\smpc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp\smpm;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\host\smp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\bas\bass\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\dis\diss\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\rwble;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\rwble_hl;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\ea\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\em\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\common_project_files;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\boot\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\compiler\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\ll\rvds;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch\main;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\arch;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\arch_console;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\common\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\crypto;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\dbg\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\gtl\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\ke\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\ke\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\nvds\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\rf\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\gtl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\rwip\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\core_modules\h4tl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\adc;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\battery;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\gpio;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\i2c_eeprom;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\reg;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\spi;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\spi_flash;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\syscntl;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\systick;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\trng;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\uart;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\wkupct_quadec;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\ble;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\driver\hw_otpc;.\..\src\config;.\..\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\platform\system_library\include;..\src\custom_profile;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\lan;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\cpp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\rscp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\pasp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\cscp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\anp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\hrp;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\hci\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\hci\src;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find\findt\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\find\findl\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\custom;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\ble_stack\profiles\custom\custs\api;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\third_party\hash;C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_586.txt" C:\Users\imorris\Documents\SDKs\BLE\SDK\DA14585_SDK_6.0.10.511_0_Public\\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=ble_burst_adv_586_symdef.txt --any_placement=best_fit --datacompressor off
