# Keil uVision project ble_temperature_ntf.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_temperature_ntf_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: C:\Users\tbeijloo\Downloads\GITs\GIT\sdk6\ble_temperature_ntf\src\;C:\Users\tbeijloo\Downloads\GITs\GIT\sdk6\ble_temperature_ntf\src\custom_profile\;C:\Users\tbeijloo\Downloads\GITs\GIT\sdk6\ble_temperature_ntf\src\config\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_ancc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bass\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bcss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bmss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bond_db\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_common\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_ctsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_ctss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_custs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_default_hnd\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_diss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_easy\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_entry\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_findme\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_gattc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_proxr\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_sec\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_suotar\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_udss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_wsss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\em\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\llc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\lld\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\llm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\ea\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\ea\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\em\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\em\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\hci\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\hci\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\hci\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\attc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\attm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\atts\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gap\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gap\gapc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gap\gapm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gatt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gatt\gattc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gatt\gattm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\l2c\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\l2c\l2cc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\l2c\l2cm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\smp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\smp\smpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\smp\smpm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findl\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findl\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findt\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findt\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\rwble\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\rwble_hl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\ldscripts\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\misc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\scatterfiles\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\boot\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\boot\ARM\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\boot\GCC\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\compiler\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\compiler\ARM\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\compiler\GCC\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\ll\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\main\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\arch_console\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\common\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\common\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\crypto\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\dbg\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\dbg\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\gtl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\gtl\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\gtl\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\h4tl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\h4tl\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\ke\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\ke\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\ke\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\nvds\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\nvds\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\nvds\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rf\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rf\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rf\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rwip\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rwip\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rwip\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\adc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\battery\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\ble\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\dma\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\gpio\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\hw_otpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\i2c\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\i2c_eeprom\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\pdm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\reg\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\rtc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\spi\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\spi_flash\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\syscntl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\systick\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\timer\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\trng\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\uart\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\wkupct_quadec\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\include\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\include\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\output\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\output\Keil_5\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\utilities\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\utilities\otp_cs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\utilities\otp_hdr\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\crc32\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\hash\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\irng\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\micro_ecc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\rand\
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\\sdk\common_project_files\misc\da14585_symbols.txt      --symdefs=ble_app_peripheral_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//third_party/rand/: chacha20.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//third_party/hash/: hash.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/syscntl/: syscntl.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/gpio/: gpio.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/i2c/: i2c.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/uart/: uart.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/trng/: trng.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/driver/dma/: dma.c
  group sdk_ble
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/ble_stack/rwble/: rwble.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/core_modules/rwip/src/: rwip.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
  group sdk_profiles
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/ble_stack/host/att/attm/: attm_db_128.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/ble_stack/profiles/: prf_utils.c prf.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/ble_stack/profiles/custom/: custom_common.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
  group sdk_app
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/Users/tbeijloo/Downloads/SDKs/6.0.12.1020//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c user_peripheral.c MCP9808.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: ble_temperature_ntf_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 wLevel=2
  c define: __DA14586__
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: C:\Users\tbeijloo\Downloads\GITs\GIT\sdk6\ble_temperature_ntf\src\;C:\Users\tbeijloo\Downloads\GITs\GIT\sdk6\ble_temperature_ntf\src\custom_profile\;C:\Users\tbeijloo\Downloads\GITs\GIT\sdk6\ble_temperature_ntf\src\config\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_ancc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bass\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bcss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bmss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_bond_db\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_common\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_ctsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_ctss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_custs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_default_hnd\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_diss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_easy\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_entry\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_findme\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_gattc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_proxr\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_sec\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_suotar\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_udss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\app_modules\src\app_wsss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\em\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\llc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\lld\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\controller\llm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\ea\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\ea\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\em\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\em\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\hci\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\hci\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\hci\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\attc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\attm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\att\atts\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gap\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gap\gapc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gap\gapm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gatt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gatt\gattc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\gatt\gattm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\l2c\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\l2c\l2cc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\l2c\l2cm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\smp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\smp\smpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\host\smp\smpm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anc\ancc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\anp\anps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\basc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bas\bass\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bcs\bcss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\blp\blps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\bms\bmss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cppc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cpp\cpps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cscp\cscps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\cts\ctss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\custom\custs\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\disc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\dis\diss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findl\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findl\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findt\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\find\findt\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\gatt\gatt_client\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\glp\glps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpbh\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogpd\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hogp\hogprh\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\hrp\hrps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\htp\htpt\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lanc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\lan\lans\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\paspc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\pasp\pasps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxm\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\prox\proxr\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscpc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\rscp\rscps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scppc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\scpp\scpps\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\suota\suotar\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tipc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\tip\tips\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udsc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\uds\udss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wssc\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\profiles\wss\wsss\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\rwble\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\ble_stack\rwble_hl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\ldscripts\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\misc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\common_project_files\scatterfiles\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\boot\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\boot\ARM\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\boot\GCC\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\compiler\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\compiler\ARM\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\compiler\GCC\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\ll\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\arch\main\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\arch_console\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\common\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\common\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\crypto\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\dbg\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\dbg\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\gtl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\gtl\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\gtl\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\h4tl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\h4tl\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\ke\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\ke\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\ke\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\nvds\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\nvds\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\nvds\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rf\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rf\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rf\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rwip\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rwip\api\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\core_modules\rwip\src\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\adc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\battery\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\ble\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\dma\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\gpio\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\hw_otpc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\i2c\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\i2c_eeprom\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\pdm\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\reg\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\rtc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\spi\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\spi_flash\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\syscntl\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\systick\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\timer\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\trng\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\uart\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\driver\wkupct_quadec\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\include\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\include\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\output\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\system_library\output\Keil_5\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\utilities\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\utilities\otp_cs\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\sdk\platform\utilities\otp_hdr\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\crc32\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\hash\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\irng\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\micro_ecc\;C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\third_party\rand\;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\\sdk\common_project_files\misc\da14585_symbols.txt      --symdefs=ble_app_peripheral_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_temperature_ntf_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\Users\tbeijloo\Downloads\SDKs\6.0.12.1020\\sdk\common_project_files\misc\da14531_symbols.txt      --symdefs=ble_app_peripheral_531_symdef.txt --any_placement=best_fit --datacompressor off
