# Keil uVision project mCube_mc36xx_data_notifcation.uvprojx, settings and files
target mCube_mc36xx_data_notifcation_585 (6190000::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mCube_mc36xx_data_notifcation_585 +hex
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c misc: -mthumb -c -include da1458x_config_basic.h -include da1458x_config_advanced.h -include user_config.h
  c include: ..\;..\assets;..\project_environment;..\src;..\src\config;..\src\custom_profile;..\src\platform;..\src\user_app;..\src\user_drivers;..\src\user_drivers\platform;..\src\user_drivers\platform\bus;..\src\user_drivers\platform\console;..\src\user_drivers\sensor;..\src\user_drivers\sensor\accel;..\src\user_drivers\sensor\accel\mc36xx;..\src;..\src\config;..\src\custom_profile;..\src\platform;..\src\user_app;..\src\user_drivers;..\src\user_drivers\platform;..\src\user_drivers\platform\bus;..\src\user_drivers\platform\console;..\src\user_drivers\sensor;..\src\user_drivers\sensor\accel;..\src\user_drivers\sensor\accel\mc36xx;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_ancc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_bass;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_bcss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_bmss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_bond_db;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_cgms;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_common;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_ctsc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_ctss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_custs;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_default_hnd;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_diss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_easy;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_entry;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_findme;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_gattc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_glps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_lecb;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_plxs;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_proxr;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_sec;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_suotar;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_udss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\app_modules\src\app_wsss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\controller;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\controller\em;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\controller\llc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\controller\lld;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\controller\llm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\ea;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\ea\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\em;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\em\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\hci;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\hci\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\hci\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\att;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\att\attc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\att\attm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\att\atts;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\gap;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\gap\gapc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\gap\gapm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\gatt;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\gatt\gattc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\gatt\gattm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\l2c;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\l2c\l2cc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\l2c\l2cm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\smp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\smp\smpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\host\smp\smpm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anc\ancc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anc\ancc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anc\ancc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp\anpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp\anpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp\anpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp\anps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp\anps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\anp\anps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas\basc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas\basc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas\basc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas\bass;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas\bass\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bas\bass\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs\bcsc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs\bcsc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs\bcsc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs\bcss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs\bcss\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bcs\bcss\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp\blpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp\blpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp\blpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp\blps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp\blps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\blp\blps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms\bmsc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms\bmsc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms\bmsc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms\bmss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms\bmss\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\bms\bmss\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cgmp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cgmp\cgms;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cgmp\cgms\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cgmp\cgms\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp\cppc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp\cppc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp\cppc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp\cpps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp\cpps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cpp\cpps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp\cscpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp\cscpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp\cscpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp\cscps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp\cscps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cscp\cscps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts\ctsc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts\ctsc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts\ctsc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts\ctss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts\ctss\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\cts\ctss\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\custom;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\custom\custs;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\custom\custs\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\custom\custs\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis\disc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis\disc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis\disc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis\diss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis\diss\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\dis\diss\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find\findl;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find\findl\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find\findl\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find\findt;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find\findt\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\find\findt\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\gatt;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\gatt\gatt_client;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp\glpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp\glpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp\glpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp\glps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp\glps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\glp\glps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogpbh;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogpd;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogpd\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogpd\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogprh;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogprh\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hogp\hogprh\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp\hrpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp\hrpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp\hrpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp\hrps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp\hrps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\hrp\hrps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp\htpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp\htpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp\htpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp\htpt;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp\htpt\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\htp\htpt\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan\lanc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan\lanc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan\lanc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan\lans;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan\lans\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\lan\lans\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp\paspc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp\paspc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp\paspc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp\pasps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp\pasps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\pasp\pasps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\plx;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\plx\plxs;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\plx\plxs\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\plx\plxs\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox\proxm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox\proxm\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox\proxm\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox\proxr;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox\proxr\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\prox\proxr\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp\rscpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp\rscpc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp\rscpc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp\rscps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp\rscps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\rscp\rscps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp\scppc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp\scppc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp\scppc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp\scpps;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp\scpps\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\scpp\scpps\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\suota;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\suota\suotar;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\suota\suotar\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\suota\suotar\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip\tipc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip\tipc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip\tipc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip\tips;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip\tips\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\tip\tips\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds\udsc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds\udsc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds\udsc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds\udss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds\udss\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\uds\udss\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss\wssc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss\wssc\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss\wssc\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss\wsss;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss\wsss\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\profiles\wss\wsss\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\rwble;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\ble_stack\rwble_hl;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\common_project_files;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\common_project_files\IAR;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\common_project_files\ldscripts;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\common_project_files\misc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\common_project_files\scatterfiles;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\asm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\asm\ARM;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\asm\IAR;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\boot;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\boot\ARM;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\boot\GCC;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\boot\IAR;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\boot\LLVM;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\compiler;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\fpga;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\ll;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\arch\main;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\arch_console;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\common;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\common\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\crypto;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\dbg;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\dbg\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\gtl;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\gtl\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\gtl\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\h4tl;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\h4tl\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\ke;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\ke\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\ke\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\nvds;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\nvds\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\nvds\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\rf;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\rf\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\rf\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\rwip;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\rwip\api;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\core_modules\rwip\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\adc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\battery;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\ble;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\dma;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\gpio;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\hw_otpc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\i2c;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\i2c_eeprom;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\pdm;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\reg;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\rtc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\spi;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\spi_flash;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\spi_hddr;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\syscntl;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\systick;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\timer;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\trng;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\uart;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\wifi;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\driver\wkupct_quadec;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS\5.6.0;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS\5.6.0\Include;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS\5.9.0;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS\5.9.0\CMSIS;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\include;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\output;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\output\IAR;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\output\Keil_5;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\src;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\src\DA14531;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\src\DA14531_01;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\src\DA14535;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\system_library\src\DA14585_586;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\utilities;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\utilities\fsp;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\utilities\otp_cs;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\platform\utilities\otp_hdr;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\third_party;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\third_party\crc32;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\third_party\hash;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\third_party\irng;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\third_party\micro_ecc;C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: C:\work\DA145xx_SDK\All_examples_update\6.0.22.1401\sdk\common_project_files\misc\da14585_symbols.txt   --symdefs=mc36xx_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/arch/boot/: system_DA14585_586.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/arch/main/: jump_table.c arch_sleep.c arch_system.c arch_rom.c arch_main.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/third_party/rand/: chacha20.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/third_party/hash/: hash.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/system_library/output/Keil_5/: da14585_586.lib
  group sdk_driver
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/syscntl/: syscntl.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/gpio/: gpio.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/battery/: battery.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/adc/: adc_58x.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/trng/: trng.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/spi/: spi_58x.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/uart/: uart.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/i2c/: i2c.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_ble
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/ble_stack/rwble/: rwble.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/core_modules/rwip/src/: rwip.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/core_modules/rf/src/: rf_585.c
  group sdk_profiles
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/ble_stack/profiles/: prf_utils.c prf.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/ble_stack/profiles/custom/: custom_common.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/ble_stack/host/att/attm/: attm_db_128.c
  group sdk_app
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_timer.c app_easy_security.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group sdk_driver_api
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/adc/: adc.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/battery/: battery.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/gpio/: gpio.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/spi/: spi.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/spi_flash/: spi_flash.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/systick/: systick.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/trng/: trng.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/uart/: uart.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/arch/: arch_api.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/arch/main/: arch_wdg.h
    C:/work/DA145xx_SDK/All_examples_update/6.0.22.1401/sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/user_app/: user_accelerometer.c
  group user_drivers
    ../src/user_drivers/platform/bus/: m_drv_interface.c
    ../src/user_drivers/platform/console/: m_drv_console.c
    ../src/user_drivers/sensor/accel/: m_drv_mc_utility.c
    ../src/user_drivers/sensor/accel/mc36xx/: m_drv_mc36xx.c
