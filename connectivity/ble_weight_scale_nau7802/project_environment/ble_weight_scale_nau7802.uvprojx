# Keil uVision project ble_weight_scale_nau7802.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_weight_scale_nau7802 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;..\src\user_drivers;.\..\..\..\..\..\\sdk;.\..\..\..\..\..\\sdk\6.0.18.1182.1;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14531;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14531\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14531_01;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14531_01\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14585;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14585\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14586;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\da14586\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\mkimage;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\prod_test_cmds;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\proximity;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\proximity\monitor;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\proximity\reporter;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\suota;.\..\..\..\..\..\\sdk\6.0.18.1182.1\binaries\host\windows\suota\initiator;.\..\..\..\..\..\\sdk\6.0.18.1182.1\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\config\toolbox_resources;.\..\..\..\..\..\\sdk\6.0.18.1182.1\config\toolbox_resources\DA1453x;.\..\..\..\..\..\\sdk\6.0.18.1182.1\config\toolbox_resources\DA1453x\common;.\..\..\..\..\..\\sdk\6.0.18.1182.1\config\toolbox_resources\DA14585-586;.\..\..\..\..\..\\sdk\6.0.18.1182.1\config\toolbox_resources\DA14585-586\common;.\..\..\..\..\..\\sdk\6.0.18.1182.1\doc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\doc\da14531;.\..\..\..\..\..\\sdk\6.0.18.1182.1\doc\da14585_586;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\hooks;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\info;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\logs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\logs\refs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\logs\refs\heads;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\logs\refs\remotes;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\logs\refs\remotes\origin;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\objects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\objects\info;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\objects\pack;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\refs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\refs\heads;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\refs\remotes;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\refs\remotes\origin;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\.git\refs\tags;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\active_scanner\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\advertising_example;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\advertising_example\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\advertising_example\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\advertising_example\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\advertising_example\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\advertising_example\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble-Midi\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\src\keyboard_module;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\src\keyboard_module\port;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\BLE2IR\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_burst_adv;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_burst_adv\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_burst_adv\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_burst_adv\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_burst_adv\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_burst_adv\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_Notify_button_Wakeup\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\project_environment\out_DA14585;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\project_environment\out_DA14585\Listings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\project_environment\out_DA14585\Objects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\src\user_app;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_pressure_sensor_bmp388\src\user_drivers;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ble_temperature_ntf\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\central_Security_Demo\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example\media;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example\project_enviroment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Coexistence-example\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc\project_enviornment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\dyn_custom_svc\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\hibernation_and_stateaware_hibernation;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\hibernation_and_stateaware_hibernation\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\hibernation_and_stateaware_hibernation\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\hibernation_and_stateaware_hibernation\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\hibernation_and_stateaware_hibernation\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\hibernation_and_stateaware_hibernation\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim\src\modified_files;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\ibeacon_Optim\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multirole\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph\project_enviroment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\multi_con_periph\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\modules_lib;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\modules_lib\app;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\modules_lib\app\wkup_keys;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\modules_lib\port;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\user_drivers;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\Quuppa_DialogTag\src\user_drivers\bmi270;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example\project_environement;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\RTC_Example\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track\project_enviroment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\scan_request_track\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\simple_beacon\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\svc_data_beacon\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles\project environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\connectivity\switching_roles\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\DA14531_Timer1_SW_Example\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\dynamic_L2CAP_Packet_size_Optimization\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\reset_Indication_update\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\features\social-distancing-application\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\src\app_common;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\src\main;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\helpers\usb_preloaded _firmware\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\img;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\src\user_app;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\accel-Sensor\src\user_drivers;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\e2studio;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\e2studio\script;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\e2studio\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\e2studio\src\SEGGER_RTT;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\MDK-ARM;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\MDK-ARM\script;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\MDK-ARM\script\ac6;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\MDK-ARM\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-renesas\project_environment\MDK-ARM\src\SEGGER_RTT;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\DA14531;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core\Template;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core\Template\ARMv8-M;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core_A;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core_A\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Core_A\Source;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Device;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Device\ST;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Device\ST\STM32F4xx;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\docs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\docs\General;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\docs\General\html;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Lib;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Lib\ARM;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Lib\GCC;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\Lib\IAR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\RTOS;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\RTOS\Template;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\RTOS2;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\RTOS2\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\RTOS2\Source;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\CMSIS\RTOS2\Template;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\STM32F4xx_HAL_Driver;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\STM32F4xx_HAL_Driver\Inc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Drivers\STM32F4xx_HAL_Driver\Src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Inc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\MDK-ARM;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\MDK-ARM\DebugConfig;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\MDK-ARM\RTE;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\MDK-ARM\RTE\_codeless_boot;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\external-processor-stm32\project_environment\Src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\HID-Gamepad-Digitizer\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment\out_DA14531;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment\out_DA14531\Listings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment\out_DA14531\Objects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment\out_DA14585;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment\out_DA14585\Listings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\project_environment\out_DA14585\Objects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Master\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Slave;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Slave\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Slave\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\I2C-Master-Slave\I2C_Slave\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_app;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers\platform\bus;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers\platform\console;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers\sensor;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers\sensor\accel;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\MCube-Accel-MC36xx\src\user_drivers\sensor\accel\mc36xx;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\segger_rtt\src\RTT;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\simple_button;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\simple_button\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\simple_button\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\simple_button\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\simple_button\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Master;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Master\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Master\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Master\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Slave;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Slave\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Slave\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI-Master-Slave\SPI_Slave\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI_or_I2C_DMA_accelerometer;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI_or_I2C_DMA_accelerometer\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI_or_I2C_DMA_accelerometer\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI_or_I2C_DMA_accelerometer\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI_or_I2C_DMA_accelerometer\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\SPI_or_I2C_DMA_accelerometer\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup-button;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup-button\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup-button\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup-button\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup-button\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup-button\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup_hibernation_ext_timer;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup_hibernation_ext_timer\assets;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup_hibernation_ext_timer\project_environment;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup_hibernation_ext_timer\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup_hibernation_ext_timer\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\BLE_SDK6_examples\interfaces\wakeup_hibernation_ext_timer\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\monitor;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\monitor\.settings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\monitor\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\monitor\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\reporter;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\reporter\.settings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\reporter\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\proximity\reporter\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\suota;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\suota\initiator;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\suota\initiator\.settings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\suota\initiator\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\host_apps\windows\suota\initiator\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\Keil_5\out_DA14585;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\Keil_5\out_DA14585\Listings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\Keil_5\out_DA14585\Objects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_all_in_one\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_barebone;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_barebone\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_barebone\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_barebone\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_barebone\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_ota;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_ota\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_ota\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_ota\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_ota\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_ota\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_peripheral;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_peripheral\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_peripheral\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_peripheral\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_peripheral\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_peripheral\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_profile\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_profile\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_profile\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_profile\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_profile\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_security;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_security\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_security\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_security\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_security\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_security\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_sleepmode;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_sleepmode\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_sleepmode\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_sleepmode\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_sleepmode\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\ble_app_sleepmode\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_monitor_ext;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_monitor_ext\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_monitor_ext\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_monitor_ext\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_monitor_ext\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\Eclipse;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\IAR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\IAR\scripts;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter_ext;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter_ext\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter_ext\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter_ext\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\ble_examples\prox_reporter_ext\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\hci;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\hci\hci;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\hci\hci\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\hci\hci\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\hci\hci\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\hci\hci\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\aes;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\aes\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\aes\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\aes\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\aes\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ancs_client;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ancs_client\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ancs_client\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ancs_client\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ancs_client\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ble_app_noncon;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ble_app_noncon\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ble_app_noncon\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ble_app_noncon\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\misc\ble_app_noncon\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\adc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\adc\batt_lvl;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\adc\batt_lvl\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\adc\batt_lvl\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\adc\batt_lvl\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\blinky;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\blinky\blinky;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\blinky\blinky\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\blinky\blinky\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\blinky\blinky\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\i2c;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\i2c\i2c_eeprom;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\i2c\i2c_eeprom\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\i2c\i2c_eeprom\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\i2c\i2c_eeprom\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\quadrature_decoder;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\quadrature_decoder\quadrature_decoder;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\quadrature_decoder\quadrature_decoder\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\quadrature_decoder\quadrature_decoder\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\quadrature_decoder\quadrature_decoder\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\shared;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\shared\source;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\spi;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\spi\spi_flash;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\spi\spi_flash\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\spi\spi_flash\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\spi\spi_flash\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\systick;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\systick\systick;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\systick\systick\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\systick\systick\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\systick\systick\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_general;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_general\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_general\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_general\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_pwm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_pwm\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_pwm\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer0\timer0_pwm\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer2;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer2\timer2_pwm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer2\timer2_pwm\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer2\timer2_pwm\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\timer2\timer2_pwm\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\uart;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\uart\uart;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\uart\uart\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\uart\uart\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\peripheral_examples\uart\uart\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test\prod_test\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test\prod_test\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test\prod_test\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test\prod_test\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\prod_test\prod_test\src\system;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\Keil_5\out_DA14585;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\Keil_5\out_DA14585\Listings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\Keil_5\out_DA14585\Objects;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_peripheral_template\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_template_ext;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_template_ext\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_template_ext\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_template_ext\src\config;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_template_ext\src\custom_profile;.\..\..\..\..\..\\sdk\6.0.18.1182.1\projects\target_apps\template\empty_template_ext\src\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_ancc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_bass;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_bcss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_bmss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_bond_db;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_common;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_ctsc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_ctss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_custs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_default_hnd;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_diss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_easy;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_entry;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_findme;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_gattc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_sec;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_udss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\app_modules\src\app_wsss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\controller;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\controller\em;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\controller\llc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\controller\lld;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\controller\llm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\ea;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\ea\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\em;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\em\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\hci;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\hci\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\hci\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\att;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\gap;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\gatt;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\l2c;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\smp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find\findl\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\find\findt\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\gatt;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\suota;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\rwble;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\common_project_files;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\common_project_files\IAR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\common_project_files\ldscripts;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\common_project_files\misc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\common_project_files\scatterfiles;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\boot;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\boot\ARM_clang;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\boot\IAR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\compiler;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\compiler\ARM_clang;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\compiler\IAR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\ll;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\arch\main;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\common;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\common\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\crypto;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\dbg;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\gtl;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\h4tl;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\ke;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\nvds;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\nvds\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\rf;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\rf\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\rwip;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\core_modules\rwip\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\adc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\battery;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\ble;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\dma;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\gpio;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\i2c;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\pdm;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\reg;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\rtc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\spi;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\spi_flash;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\syscntl;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\systick;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\timer;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\trng;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\uart;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\wifi;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS\5.6.0;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS\5.6.0\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\system_library;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\system_library\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\system_library\output;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\system_library\output\IAR;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\system_library\output\Keil_5;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\utilities;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\utilities\otp_cs;.\..\..\..\..\..\\sdk\6.0.18.1182.1\sdk\platform\utilities\otp_hdr;.\..\..\..\..\..\\sdk\6.0.18.1182.1\third_party;.\..\..\..\..\..\\sdk\6.0.18.1182.1\third_party\crc32;.\..\..\..\..\..\\sdk\6.0.18.1182.1\third_party\hash;.\..\..\..\..\..\\sdk\6.0.18.1182.1\third_party\irng;.\..\..\..\..\..\\sdk\6.0.18.1182.1\third_party\micro_ecc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\third_party\rand;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\flash_programmer;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\flash_programmer\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\flash_programmer\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\flash_programmer\startup;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\mkimage;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\mkimage\gcc;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\prod_test;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\prod_test\prod_test_cmds;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\prod_test\prod_test_cmds\prodtest;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\prod_test\prod_test_cmds\prodtest\.settings;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\prod_test\prod_test_cmds\prodtest\include;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\prod_test\prod_test_cmds\prodtest\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\secondary_bootloader;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\secondary_bootloader\includes;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\secondary_bootloader\src;.\..\..\..\..\..\\sdk\6.0.18.1182.1\utilities\secondary_bootloader\startup;
  library: MicroLIB
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\DA14585_586_armclang.sct
  link misc: --feedback=".\unused_585.txt" .\..\..\..\..\..\\sdk\common_project_files\misc\da14585_symbols.txt      --symdefs=ble_app_peripheral_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../..//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ./../../../../..//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ./../../../../..//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../..//sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../..//sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../..//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    ./../../../../..//third_party/rand/: chacha20.c
    ./../../../../..//third_party/hash/: hash.c
    ./../../../../..//sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    ./../../../../..//sdk/platform/utilities/otp_cs/: otp_cs.c
    ./../../../../..//sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    ./../../../../..//sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../..//sdk/platform/driver/gpio/: gpio.c
    ./../../../../..//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../..//sdk/platform/driver/adc/: adc_58x.c adc_531.c
    ./../../../../..//sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ./../../../../..//sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../..//sdk/platform/driver/i2c/: i2c.c
    ./../../../../..//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../../../..//sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ./../../../../..//sdk/platform/driver/uart/: uart.c
    ./../../../../..//sdk/platform/driver/trng/: trng.c
    ./../../../../..//sdk/platform/driver/dma/: dma.c
  group sdk_ble
    ./../../../../..//sdk/ble_stack/rwble/: rwble.c
    ./../../../../..//sdk/platform/core_modules/rwip/src/: rwip.c
    ./../../../../..//sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
  group sdk_profiles
    ./../../../../..//sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../..//sdk/ble_stack/profiles/: prf_utils.c prf.c
    ./../../../../..//sdk/ble_stack/profiles/custom/: custom_common.c
    ./../../../../..//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ./../../../../..//sdk/ble_stack/profiles/custom/custs/src/: custs1_task.c custs1.c
    ./../../../../..//sdk/ble_stack/profiles/wss/wsss/src/: wsss.c wsss_task.c
  group sdk_app
    ./../../../../..//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../..//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    ./../../../../..//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../../..//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../../../../..//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ./../../../../..//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ./../../../../..//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ./../../../../..//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ./../../../../..//sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../../..//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ./../../../../..//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ./../../../../..//sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ./../../../../..//sdk/app_modules/src/app_wsss/: app_wsss.c app_wsss_task.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c user_custs1_impl.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: ble_weight_scale_nau7802.c
  group user_drivers
    ../src/user_drivers/: nau7802.c i2cm.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: ble_pressure_sensor_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 wLevel=2
  c define: __DA14586__
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  scatter file: as above
  link misc: --feedback=".\unused_586.txt" .\..\..\..\..\..\\sdk\common_project_files\misc\da14585_symbols.txt      --symdefs=ble_app_peripheral_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_weight_scale_nau7802_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DA14531__
  c misc: -mthumb -c -include da1458x_config_basic.h -include da1458x_config_advanced.h -include user_config.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\DA14531_armclang.sct
  link misc: .\..\..\..\..\..\\sdk\common_project_files\misc\da14531_symbols.txt      --symdefs=ble_weight_scale_nau7802_531_symdef.txt --any_placement=best_fit --datacompressor off
