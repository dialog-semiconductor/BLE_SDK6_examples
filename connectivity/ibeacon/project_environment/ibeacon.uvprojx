# Keil uVision project ibeacon.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ibeacon_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: .\..\..\..\..\;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" .\..\..\..\..\\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=ibeacon_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../..//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ./../../../..//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ./../../../..//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../..//sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../..//sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../..//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_rom.c
    ./../../../..//third_party/rand/: chacha20.c
    ./../../../..//third_party/hash/: hash.c
    ./../../../..//sdk/platform/system_library/output/Keil_5/: da14531.lib da14585_586.lib
    ./../../../..//sdk/platform/utilities/otp_cs/: otp_cs.c
    ./../../../..//sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    ./../../../..//sdk/platform/driver/syscntl/: syscntl.c
    ./../../../..//sdk/platform/driver/adc/: adc_531.c adc_58x.c
    ./../../../..//sdk/platform/driver/trng/: trng.c
    ./../../../..//sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ./../../../..//sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../..//sdk/platform/driver/systick/: systick.c
    ./../../../..//sdk/platform/driver/gpio/: gpio.c
    ./../../../..//sdk/platform/driver/hw_otpc/: hw_otpc_531.c hw_otpc_58x.c
  group sdk_ble
    ./../../../..//sdk/ble_stack/rwble/: rwble.c
    ./../../../..//sdk/platform/core_modules/rwip/src/: rwip.c
    ./../../../..//sdk/platform/core_modules/rf/src/: ble_arp.c rf_531.c rf_585.c
  group sdk_profiles
    ./../../../..//sdk/ble_stack/profiles/: prf.c
  group sdk_app
    ./../../../..//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../..//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    ./../../../..//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../..//sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../..//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ./../../../..//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_app.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: ibeacon_586 +hex
  AfterMake: as above
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: .\..\..\..\..\;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" .\..\..\..\..\\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=ibeacon_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ibeacon_531 +hex
  AfterMake: as above
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: .\..\..\..\..\;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" .\..\..\..\..\\sdk\common_project_files\misc\da14531_symbols.txt  --symdefs=ibeacon_symdef.txt --any_placement=best_fit --datacompressor off
