# Keil uVision project multi_con_periph.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: multi_con_periph_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: .\..\..\..\..\;
  library: MicroLIB
  scatter file: .\..\..\..\..\\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" .\..\..\..\..\\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=empty_peripheral_template_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../..//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ./../../../..//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ./../../../..//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../..//sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../..//sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../..//sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_hibernation.c arch_rom.c
    ./../../../..//third_party/rand/: chacha20.c
    ./../../../..//third_party/hash/: hash.c
    ./../../../..//sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    ./../../../..//sdk/platform/utilities/otp_cs/: otp_cs.c
    ./../../../..//sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    ./../../../..//sdk/platform/driver/syscntl/: syscntl.c
    ./../../../..//sdk/platform/driver/gpio/: gpio.c
    ./../../../..//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../..//sdk/platform/driver/battery/: battery.c
    ./../../../..//sdk/platform/driver/adc/: adc_58x.c adc_531.c
    ./../../../..//sdk/platform/driver/trng/: trng.c
    ./../../../..//sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ./../../../..//sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../..//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../../..//sdk/platform/driver/systick/: systick.c
    ./../../../..//sdk/platform/driver/uart/: uart.c
    ./../../../..//sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ./../../../..//sdk/platform/driver/dma/: dma.c
    ./../../../..//sdk/platform/driver/i2c/: i2c.c
  group sdk_ble
    ./../../../..//sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    ./../../../..//sdk/ble_stack/rwble/: rwble.c
    ./../../../..//sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    ./../../../..//sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../..//sdk/ble_stack/profiles/bas/basc/src/: basc.c basc_task.c
    ./../../../..//sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    ./../../../..//sdk/ble_stack/profiles/blp/blpc/src/: blpc.c blpc_task.c
    ./../../../..//sdk/ble_stack/profiles/blp/blps/src/: blps.c blps_task.c
    ./../../../..//sdk/ble_stack/profiles/dis/disc/src/: disc.c disc_task.c
    ./../../../..//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ./../../../..//sdk/ble_stack/profiles/find/findt/src/: findt.c findt_task.c
    ./../../../..//sdk/ble_stack/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    ./../../../..//sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ./../../../..//sdk/ble_stack/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    ./../../../..//sdk/ble_stack/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    ./../../../..//sdk/ble_stack/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    ./../../../..//sdk/ble_stack/profiles/htp/htpc/src/: htpc.c htpc_task.c
    ./../../../..//sdk/ble_stack/profiles/htp/htpt/src/: htpt.c htpt_task.c
    ./../../../..//sdk/ble_stack/profiles/prox/proxm/src/: proxm.c proxm_task.c
    ./../../../..//sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ./../../../..//sdk/ble_stack/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    ./../../../..//sdk/ble_stack/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    ./../../../..//sdk/ble_stack/profiles/anp/anpc/src/: anpc.c anpc_task.c
    ./../../../..//sdk/ble_stack/profiles/anp/anps/src/: anps.c anps_task.c
    ./../../../..//sdk/ble_stack/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    ./../../../..//sdk/ble_stack/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    ./../../../..//sdk/ble_stack/profiles/glp/glpc/src/: glpc.c glpc_task.c
    ./../../../..//sdk/ble_stack/profiles/glp/glps/src/: glps.c glps_task.c
    ./../../../..//sdk/ble_stack/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    ./../../../..//sdk/ble_stack/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    ./../../../..//sdk/ble_stack/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    ./../../../..//sdk/ble_stack/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    ./../../../..//sdk/ble_stack/profiles/tip/tipc/src/: tipc.c tipc_task.c
    ./../../../..//sdk/ble_stack/profiles/tip/tips/src/: tips.c tips_task.c
    ./../../../..//sdk/ble_stack/profiles/find/findl/src/: findl.c findl_task.c
    ./../../../..//sdk/ble_stack/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    ./../../../..//sdk/ble_stack/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    ./../../../..//sdk/ble_stack/profiles/lan/lanc/src/: lanc.c lanc_task.c
    ./../../../..//sdk/ble_stack/profiles/lan/lans/src/: lans.c lans_task.c
    ./../../../..//sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    ./../../../..//sdk/ble_stack/profiles/custom/: custom_common.c
    ./../../../..//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    ./../../../..//sdk/ble_stack/profiles/: prf.c prf_utils.c
  group sdk_app
    ./../../../..//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../..//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    ./../../../..//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../..//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../../../..//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ./../../../..//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ./../../../..//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ./../../../..//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ./../../../..//sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../..//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c app_easy_whitelist.c
    ./../../../..//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ./../../../..//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ./../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ./../src/platform/: user_periph_setup.c
  group user_app
    ./../src/: user_multi_peripheral.c
    ../src/: user_custs1_impl.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: empty_peripheral_template_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: .\..\..\..\..\;
  library: MicroLIB
  scatter file: .\..\..\..\..\\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" .\..\..\..\..\\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=empty_peripheral_template_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: multi_con_periph_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__ __EXCLUDE_ROM_APP_TASK__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: .\..\..\..\..\;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\..\..\..\\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" .\..\..\..\..\\sdk\common_project_files\misc\da14531_symbols.txt --symdefs=empty_peripheral_template_531_symdef.txt --any_placement=best_fit --datacompressor off
