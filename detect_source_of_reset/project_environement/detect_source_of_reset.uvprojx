# Keil uVision project detect_source_of_reset.uvprojx, settings and files
target detect_source_of_reset_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: detect_source_of_reset_585 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: .\..\;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\include;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\api;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_bass;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_custs;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_diss;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_findme;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\ea\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\em\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\em;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\llc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\lld;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\llm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\dis\disc\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\find\findl\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\find\findt\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\hci\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\rwble;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\SW_examples_585_6\6.0.10.511\\sdk\common_project_files;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\main;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\common\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\crypto;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\adc;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\battery;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\ble;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\gpio;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\reg;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi_flash;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi_hci;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\syscntl;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\systick;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\trng;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\uart;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\dma;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\pdm;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\SW_examples_585_6\6.0.10.511\\third_party\rand;C:\SW_examples_585_6\6.0.10.511\\third_party\hash
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_585.txt" C:\SW_examples_585_6\6.0.10.511\\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=detect_source_of_reset_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/core_modules/arch_console/: arch_console.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/core_modules/nvds/src/: nvds.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/arch/main/: jump_table.c arch_sleep.c arch_system.c arch_rom.c arch_main.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/system_library/output/Keil_5/: system_library.lib
    C:/SW_examples_585_6/6.0.10.511//third_party/rand/: chacha20.c
    C:/SW_examples_585_6/6.0.10.511//third_party/hash/: hash.c
  group sdk_driver
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/syscntl/: syscntl.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/gpio/: gpio.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/battery/: battery.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/adc/: adc.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/trng/: trng.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/spi_flash/: spi_flash.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/spi/: spi.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/uart/: uart2.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/hw_otpc/: hw_otpc.c
  group sdk_ble
    C:/SW_examples_585_6/6.0.10.511//sdk/ble_stack/rwble/: rwble.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/core_modules/rwip/src/: rwip.c
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/core_modules/rf/src/: rf_585.c
  group sdk_profiles
    C:/SW_examples_585_6/6.0.10.511//sdk/ble_stack/profiles/: prf_utils.c prf.c
    C:/SW_examples_585_6/6.0.10.511//sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/ble_stack/profiles/custom/: custom_common.c
    C:/SW_examples_585_6/6.0.10.511//sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/ble_stack/host/att/attm/: attm_db_128.c
  group sdk_app
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_timer.c app_easy_security.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group sdk_driver_api
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/adc/: adc.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/battery/: battery.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/gpio/: gpio.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/spi/: spi.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/spi_flash/: spi_flash.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/systick/: systick.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/trng/: trng.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/uart/: uart.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    C:/SW_examples_585_6/6.0.10.511//sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/arch/: arch_api.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/arch/main/: arch_wdg.h
    C:/SW_examples_585_6/6.0.10.511//sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c user_application.c
target detect_source_of_reset_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: detect_source_of_reset_586 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: .\..\;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\include;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\api;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_bass;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_custs;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_diss;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_findme;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\ea\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\em\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\em;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\llc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\lld;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\llm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\dis\disc\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\find\findl\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\find\findt\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\hci\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\rwble;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\SW_examples_585_6\6.0.10.511\\sdk\common_project_files;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\main;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\common\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\crypto;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\adc;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\battery;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\ble;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\gpio;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\reg;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi_flash;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi_hci;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\syscntl;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\systick;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\trng;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\uart;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\dma;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\pdm;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\SW_examples_585_6\6.0.10.511\\third_party\rand;C:\SW_examples_585_6\6.0.10.511\\third_party\hash;.\..\;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\include;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\api;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_bass;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_custs;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_diss;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_findme;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_proxr;C:\SW_examples_585_6\6.0.10.511\\sdk\app_modules\src\app_suotar;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\ea\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\em\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\em;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\llc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\lld;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\controller\llm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\attc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\attm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\att\atts;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap\gapc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gap\gapm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt\gattc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\gatt\gattm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\l2c\l2cc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\l2c\l2cm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp\smpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp\smpm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\host\smp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anc\ancc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp\anpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp\anps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\anp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\bas\basc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\bas\bass;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp\blpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp\blps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\blp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp\cppc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp\cpps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cpp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp\cscps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\cscp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\custom;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\custom\custs\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\dis\disc\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\dis\diss\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\find\findl\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\find\findt\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp\glpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp\glps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\glp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpbh;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogpd;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp\hogprh;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hogp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp\hrps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\hrp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp\htpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp\htpt;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\htp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan\lanc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan\lans;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\lan;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp\paspc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp\pasps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\pasp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\prox\proxm;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\prox\proxr;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscpc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp\rscps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\rscp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp\scppc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp\scpps;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\scpp;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\suota\suotar\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip\tipc;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip\tips;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\tip;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\uds\udss;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\uds;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\profiles\wss\wsss;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\hci\api;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\rwble;C:\SW_examples_585_6\6.0.10.511\\sdk\ble_stack\rwble_hl;C:\SW_examples_585_6\6.0.10.511\\sdk\common_project_files;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\boot\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch\main;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\arch;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\arch_console;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\common\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\crypto;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\dbg\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\gtl\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\ke\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\ke\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\nvds\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\rf\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\rwip\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\h4tl\api;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\adc;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\battery;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\ble;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\gpio;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\hw_otpc;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\i2c_eeprom;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\reg;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi_flash;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\spi_hci;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\syscntl;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\systick;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\trng;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\uart;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\driver\wkupct_quadec;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\system_library\include;.\..\src\config;.\..\src;C:\SW_examples_585_6\6.0.10.511\\sdk\platform\core_modules\gtl\api;..\src\custom_profile;C:\SW_examples_585_6\6.0.10.511\\third_party\rand;C:\SW_examples_585_6\6.0.10.511\\third_party\hash;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter.sct
  link misc: --feedback=".\unused_586.txt" C:\SW_examples_585_6\6.0.10.511\\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=detect_source_of_reset_symdef.txt --any_placement=best_fit --datacompressor off
