# Keil uVision project detect_source_of_reset.uvprojx, settings and files
target detect_source_of_reset_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: detect_source_of_reset_585 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_ancc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_bass;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_bcss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_bmss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_bond_db;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_common;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_ctsc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_ctss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_custs;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_default_hnd;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_diss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_easy;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_entry;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_findme;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_gattc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_proxr;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_sec;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_suotar;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_udss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\app_modules\src\app_wsss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\controller;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\controller\em;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\controller\llc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\controller\lld;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\controller\llm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\ea;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\ea\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\em;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\em\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\hci;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\hci\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\hci\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\att;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\att\attc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\att\attm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\att\atts;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\gap;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\gap\gapc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\gap\gapm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\gatt;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\gatt\gattc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\gatt\gattm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\l2c;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\l2c\l2cc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\l2c\l2cm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\smp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\smp\smpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\host\smp\smpm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anc\ancc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp\anpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp\anps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\anp\anps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas\basc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas\basc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas\bass;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bas\bass\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcsc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bcs\bcss\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp\blpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp\blps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\blp\blps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms\bmsc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\bms\bmss\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp\cppc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cpp\cpps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cscp\cscps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts\ctsc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\cts\ctss\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\custom;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\custom\custs;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\custom\custs\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis\disc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis\disc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis\diss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\dis\diss\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find\findl;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find\findl\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find\findl\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find\findt;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find\findt\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\find\findt\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\gatt;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp\glpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp\glps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\glp\glps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogpd\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hogp\hogprh\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\hrp\hrps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp\htpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\htp\htpt\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan\lanc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan\lans;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\lan\lans\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp\paspc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\pasp\pasps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox\proxm\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\prox\proxr\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscpc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\rscp\rscps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp\scppc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\scpp\scpps\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\suota;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\suota\suotar\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip\tipc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip\tips;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\tip\tips\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds\udsc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds\udss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\uds\udss\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss\wssc\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\profiles\wss\wsss\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\rwble;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\ble_stack\rwble_hl;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files\IAR;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files\ldscripts;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files\misc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files\scatterfiles;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\boot;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\boot\ARM;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\boot\GCC;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\boot\IAR;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\compiler;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\compiler\ARM;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\compiler\GCC;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\compiler\IAR;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\ll;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\arch\main;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\arch_console;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\common;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\common\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\crypto;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\dbg;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\dbg\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\gtl;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\gtl\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\gtl\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\h4tl;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\h4tl\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\ke;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\ke\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\ke\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\nvds;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\nvds\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\nvds\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\rf;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\rf\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\rf\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\rwip;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\rwip\api;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\core_modules\rwip\src;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\adc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\battery;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\ble;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\dma;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\gpio;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\hw_otpc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\i2c;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\i2c_eeprom;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\pdm;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\reg;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\rtc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\spi;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\spi_flash;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\syscntl;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\systick;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\timer;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\trng;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\uart;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\wifi;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\driver\wkupct_quadec;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\include;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\include\CMSIS;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\include\CMSIS\5.6.0\Include;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\system_library;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\system_library\include;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\system_library\output;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\system_library\output\IAR;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\system_library\output\Keil_5;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\utilities;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\utilities\otp_cs;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\platform\utilities\otp_hdr;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\third_party;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\third_party\crc32;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\third_party\hash;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\third_party\irng;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\third_party\micro_ecc;C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=detect_source_of_reset_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/Release_sw_examples_585/6.0.10.511//sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/arch/main/: jump_table.c arch_sleep.c arch_system.c arch_rom.c arch_main.c
    C:/Release_sw_examples_585/6.0.10.511//sdk/platform/system_library/output/Keil_5/: system_library.lib
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/third_party/rand/: chacha20.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/third_party/hash/: hash.c
  group sdk_driver
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/syscntl/: syscntl.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/gpio/: gpio.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/battery/: battery.c
    C:/Release_sw_examples_585/6.0.10.511//sdk/platform/driver/adc/: adc.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/trng/: trng.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/Release_sw_examples_585/6.0.10.511//sdk/platform/driver/spi/: spi.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/Release_sw_examples_585/6.0.10.511//sdk/platform/driver/uart/: uart2.c
    C:/Release_sw_examples_585/6.0.10.511//sdk/platform/driver/hw_otpc/: hw_otpc.c
  group sdk_ble
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/ble_stack/rwble/: rwble.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/core_modules/rwip/src/: rwip.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/core_modules/rf/src/: rf_585.c
  group sdk_profiles
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/ble_stack/profiles/: prf_utils.c prf.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/ble_stack/profiles/custom/: custom_common.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/ble_stack/host/att/attm/: attm_db_128.c
  group sdk_app
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_timer.c app_easy_security.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group sdk_driver_api
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/adc/: adc.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/battery/: battery.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/gpio/: gpio.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/spi/: spi.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/spi_flash/: spi_flash.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/systick/: systick.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/trng/: trng.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/uart/: uart.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/arch/: arch_api.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/arch/main/: arch_wdg.h
    C:/Users/malam/JIRA/Tasks/reviews/zz_small_example_github_release/6.0.14.1114/sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c user_application.c
target detect_source_of_reset_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: detect_source_of_reset_586 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\Users\malam\JIRA\Tasks\reviews\zz_small_example_github_release\6.0.14.1114\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=detect_source_of_reset_symdef.txt --any_placement=best_fit --datacompressor off
