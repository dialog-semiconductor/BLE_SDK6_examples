# Keil uVision project i2c_async_slave.uvprojx, settings and files
target DA14585 (6190000::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: blinky_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: ..\src;..\src\config;.\..\..\..\..\..\..\\sdk;.\..\..\..\..\..\..\\sdk\app_modules;.\..\..\..\..\..\..\\sdk\app_modules\api;.\..\..\..\..\..\..\\sdk\app_modules\src;.\..\..\..\..\..\..\\sdk\app_modules\src\app_ancc;.\..\..\..\..\..\..\\sdk\app_modules\src\app_bass;.\..\..\..\..\..\..\\sdk\app_modules\src\app_bcss;.\..\..\..\..\..\..\\sdk\app_modules\src\app_bmss;.\..\..\..\..\..\..\\sdk\app_modules\src\app_bond_db;.\..\..\..\..\..\..\\sdk\app_modules\src\app_common;.\..\..\..\..\..\..\\sdk\app_modules\src\app_ctsc;.\..\..\..\..\..\..\\sdk\app_modules\src\app_ctss;.\..\..\..\..\..\..\\sdk\app_modules\src\app_custs;.\..\..\..\..\..\..\\sdk\app_modules\src\app_default_hnd;.\..\..\..\..\..\..\\sdk\app_modules\src\app_diss;.\..\..\..\..\..\..\\sdk\app_modules\src\app_easy;.\..\..\..\..\..\..\\sdk\app_modules\src\app_entry;.\..\..\..\..\..\..\\sdk\app_modules\src\app_findme;.\..\..\..\..\..\..\\sdk\app_modules\src\app_gattc;.\..\..\..\..\..\..\\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\..\\sdk\app_modules\src\app_sec;.\..\..\..\..\..\..\\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\..\\sdk\app_modules\src\app_udss;.\..\..\..\..\..\..\\sdk\app_modules\src\app_wsss;.\..\..\..\..\..\..\\sdk\ble_stack;.\..\..\..\..\..\..\\sdk\ble_stack\controller;.\..\..\..\..\..\..\\sdk\ble_stack\controller\em;.\..\..\..\..\..\..\\sdk\ble_stack\controller\llc;.\..\..\..\..\..\..\\sdk\ble_stack\controller\lld;.\..\..\..\..\..\..\\sdk\ble_stack\controller\llm;.\..\..\..\..\..\..\\sdk\ble_stack\ea;.\..\..\..\..\..\..\\sdk\ble_stack\ea\api;.\..\..\..\..\..\..\\sdk\ble_stack\em;.\..\..\..\..\..\..\\sdk\ble_stack\em\api;.\..\..\..\..\..\..\\sdk\ble_stack\hci;.\..\..\..\..\..\..\\sdk\ble_stack\hci\api;.\..\..\..\..\..\..\\sdk\ble_stack\hci\src;.\..\..\..\..\..\..\\sdk\ble_stack\host;.\..\..\..\..\..\..\\sdk\ble_stack\host\att;.\..\..\..\..\..\..\\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\..\\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\..\\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\..\\sdk\ble_stack\host\gap;.\..\..\..\..\..\..\\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\..\\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\..\\sdk\ble_stack\host\gatt;.\..\..\..\..\..\..\\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\..\\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\..\\sdk\ble_stack\host\l2c;.\..\..\..\..\..\..\\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\..\\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\..\\sdk\ble_stack\host\smp;.\..\..\..\..\..\..\\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\..\\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\..\\sdk\ble_stack\profiles;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anc\ancc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anc\ancc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp\anpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp\anpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp\anps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\anp\anps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas\basc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas\basc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas\bass\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bas\bass\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs\bcsc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs\bcsc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs\bcsc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs\bcss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs\bcss\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bcs\bcss\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp\blpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp\blpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp\blps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\blp\blps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms\bmsc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms\bmsc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms\bmsc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms\bmss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms\bmss\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\bms\bmss\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp\cppc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp\cppc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp\cpps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cpp\cpps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp\cscpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp\cscpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp\cscps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cscp\cscps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts\ctsc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts\ctsc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts\ctsc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts\ctss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts\ctss\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\cts\ctss\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\custom\custs;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\custom\custs\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis\disc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis\disc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis\diss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\dis\diss\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find\findl\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find\findl\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find\findt\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\find\findt\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\gatt;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\gatt\gatt_client;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\gatt\gatt_client\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\gatt\gatt_client\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp\glpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp\glpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp\glps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\glp\glps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogpbh\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogpbh\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogpd\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogpd\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogprh\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hogp\hogprh\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp\hrpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp\hrpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp\hrps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\hrp\hrps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp\htpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp\htpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp\htpt\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\htp\htpt\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan\lanc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan\lanc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan\lans\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\lan\lans\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp\paspc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp\paspc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp\pasps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\pasp\pasps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox\proxm\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox\proxm\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox\proxr\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\prox\proxr\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp\rscpc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp\rscpc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp\rscps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\rscp\rscps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp\scppc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp\scppc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp\scpps\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\scpp\scpps\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\suota;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\suota\suotar;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\suota\suotar\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip\tipc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip\tipc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip\tips\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\tip\tips\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds\udsc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds\udsc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds\udsc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds\udss\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\uds\udss\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss\wssc;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss\wssc\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss\wssc\src;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss\wsss\api;.\..\..\..\..\..\..\\sdk\ble_stack\profiles\wss\wsss\src;.\..\..\..\..\..\..\\sdk\ble_stack\rwble;.\..\..\..\..\..\..\\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\..\\sdk\common_project_files;.\..\..\..\..\..\..\\sdk\common_project_files\IAR;.\..\..\..\..\..\..\\sdk\common_project_files\ldscripts;.\..\..\..\..\..\..\\sdk\common_project_files\misc;.\..\..\..\..\..\..\\sdk\common_project_files\scatterfiles;.\..\..\..\..\..\..\\sdk\platform;.\..\..\..\..\..\..\\sdk\platform\arch;.\..\..\..\..\..\..\\sdk\platform\arch\boot;.\..\..\..\..\..\..\\sdk\platform\arch\boot\ARM;.\..\..\..\..\..\..\\sdk\platform\arch\boot\ARM_clang;.\..\..\..\..\..\..\\sdk\platform\arch\boot\GCC;.\..\..\..\..\..\..\\sdk\platform\arch\boot\IAR;.\..\..\..\..\..\..\\sdk\platform\arch\compiler;.\..\..\..\..\..\..\\sdk\platform\arch\compiler\ARM;.\..\..\..\..\..\..\\sdk\platform\arch\compiler\ARM_clang;.\..\..\..\..\..\..\\sdk\platform\arch\compiler\GCC;.\..\..\..\..\..\..\\sdk\platform\arch\compiler\IAR;.\..\..\..\..\..\..\\sdk\platform\arch\ll;.\..\..\..\..\..\..\\sdk\platform\arch\main;.\..\..\..\..\..\..\\sdk\platform\core_modules;.\..\..\..\..\..\..\\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\..\\sdk\platform\core_modules\common;.\..\..\..\..\..\..\\sdk\platform\core_modules\common\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\crypto;.\..\..\..\..\..\..\\sdk\platform\core_modules\dbg;.\..\..\..\..\..\..\\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\gtl;.\..\..\..\..\..\..\\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\..\\sdk\platform\core_modules\h4tl;.\..\..\..\..\..\..\\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\ke;.\..\..\..\..\..\..\\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\..\\sdk\platform\core_modules\nvds;.\..\..\..\..\..\..\\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\nvds\src;.\..\..\..\..\..\..\\sdk\platform\core_modules\rf;.\..\..\..\..\..\..\\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\rf\src;.\..\..\..\..\..\..\\sdk\platform\core_modules\rwip;.\..\..\..\..\..\..\\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\..\\sdk\platform\core_modules\rwip\src;.\..\..\..\..\..\..\\sdk\platform\driver;.\..\..\..\..\..\..\\sdk\platform\driver\adc;.\..\..\..\..\..\..\\sdk\platform\driver\battery;.\..\..\..\..\..\..\\sdk\platform\driver\ble;.\..\..\..\..\..\..\\sdk\platform\driver\dma;.\..\..\..\..\..\..\\sdk\platform\driver\gpio;.\..\..\..\..\..\..\\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\..\\sdk\platform\driver\i2c;.\..\..\..\..\..\..\\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\..\\sdk\platform\driver\pdm;.\..\..\..\..\..\..\\sdk\platform\driver\reg;.\..\..\..\..\..\..\\sdk\platform\driver\rtc;.\..\..\..\..\..\..\\sdk\platform\driver\spi;.\..\..\..\..\..\..\\sdk\platform\driver\spi_flash;.\..\..\..\..\..\..\\sdk\platform\driver\syscntl;.\..\..\..\..\..\..\\sdk\platform\driver\systick;.\..\..\..\..\..\..\\sdk\platform\driver\timer;.\..\..\..\..\..\..\\sdk\platform\driver\trng;.\..\..\..\..\..\..\\sdk\platform\driver\uart;.\..\..\..\..\..\..\\sdk\platform\driver\wifi;.\..\..\..\..\..\..\\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\..\\sdk\platform\include;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS\5.6.0;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS\5.6.0\Include;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS\5.9.0;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS\5.9.0\CMSIS;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core;.\..\..\..\..\..\..\\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;.\..\..\..\..\..\..\\sdk\platform\system_library;.\..\..\..\..\..\..\\sdk\platform\system_library\include;.\..\..\..\..\..\..\\sdk\platform\system_library\output;.\..\..\..\..\..\..\\sdk\platform\system_library\output\IAR;.\..\..\..\..\..\..\\sdk\platform\system_library\output\Keil_5;.\..\..\..\..\..\..\\sdk\platform\utilities;.\..\..\..\..\..\..\\sdk\platform\utilities\otp_cs;.\..\..\..\..\..\..\\sdk\platform\utilities\otp_hdr;.\..\..\..\..\..\..\\third_party;.\..\..\..\..\..\..\\third_party\crc32;.\..\..\..\..\..\..\\third_party\hash;.\..\..\..\..\..\..\\third_party\irng;.\..\..\..\..\..\..\\third_party\micro_ecc;.\..\..\..\..\..\..\\third_party\rand;
  library: MicroLIB
  scatter file: .\..\..\..\..\..\..\projects\target_apps\peripheral_examples\shared\peripheral_examples_armclang.sct
  group sdk_boot
    ./../../../../../..//sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ./../../../../../..//sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ./../../../../../..//projects/target_apps/peripheral_examples/shared/source/: exceptions.c
  group sdk_driver
    ./../../../../../..//sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../..//sdk/platform/driver/gpio/: gpio.c
    ./../../../../../..//sdk/platform/driver/uart/: uart.c uart_utils.c
    ./../../../../../..//sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ./../../../../../..//sdk/platform/utilities/otp_cs/: otp_cs.c
    ./../../../../../..//sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../../..//sdk/platform/driver/spi/: spi_58x.c
    ./../../../../../..//sdk/platform/driver/i2c/: i2c.c
  group user_app
    ../src/: main.c user_periph_setup.c
    ./../../../../../..//sdk/platform/arch/main/: arch_system.c
target DA14586 (6190000::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: blinky_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14586__ __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: as above
  library: MicroLIB
  scatter file: as above
target DA14531 (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: blinky_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __NON_BLE_EXAMPLE__
  c misc: -mthumb -c
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
