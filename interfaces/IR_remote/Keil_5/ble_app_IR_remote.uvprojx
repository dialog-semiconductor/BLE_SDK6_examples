# Keil uVision project ble_app_IR_remote.uvprojx, settings and files
target ble_IR_remotel_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_IR_remote_585 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\profiles\accel;.\..\..\..\..\..\sdk\ble_stack\profiles\adc_notify;.\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk\ble_stack\profiles\ieu;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk\ble_stack\profiles\mpu;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk\ble_stack\profiles\sample128;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_client;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_server;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wptc;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wpts;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt;.\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\accel;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\sdk\platform\driver\bme280;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk\platform\driver\i2c_BMI055;.\..\..\..\..\..\sdk\platform\driver\i2c_core;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\driver\inv;.\..\..\..\..\..\sdk\platform\driver\led;.\..\..\..\..\..\sdk\platform\driver\mc3410;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\rc5;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\sensor;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk\platform\driver\dma;.\..\..\..\..\..\sdk\platform\driver\pdm;.\..\..\..\..\..\sdk\platform\system_library\include;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;..\src\custom_profile;..\..\..\..\..\third_party\rand;..\..\..\..\..\third_party\hash;.\..\..\..\..\..\sdk\platform\driver\timer;.\..\src\user_driver
  library: MicroLIB
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused_585.txt" .\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt --symdefs=ble_app_barebone_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../../../../../sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../../../../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../../../../../sdk/platform/core_modules/arch_console/: arch_console.c
    ./../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
    ./../../../../../sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c
    ../../../../../sdk/platform/system_library/output/Keil_5/: system_library.lib
    ../../../../../sdk/platform/arch/main/: arch_rom.c
    ../../../../../third_party/rand/: chacha20.c
    ../../../../../third_party/hash/: hash.c
  group sdk_driver
    ./../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../sdk/platform/driver/gpio/: gpio.c
    ./../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../../../../../sdk/platform/driver/battery/: battery.c
    ./../../../../../sdk/platform/driver/adc/: adc.c
    ./../../../../../sdk/platform/driver/trng/: trng.c
    ./../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../../../../sdk/platform/driver/spi/: spi.c
    ./../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
    ../../../../../sdk/platform/driver/hw_otpc/: hw_otpc.c
    ../../../../../sdk/platform/driver/timer/: timer0.c
  group sdk_ble
    ./../../../../../sdk/ble_stack/rwble/: rwble.c
    ./../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
    ../../../../../sdk/platform/core_modules/rf/src/: rf_585.c
  group sdk_profiles
    ./../../../../../sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../../../../../sdk/ble_stack/profiles/: prf_utils.c
    ./../../../../../sdk/ble_stack/profiles/custom/: custom_common.c
    ../../../../../sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    ../../../../../sdk/ble_stack/profiles/: prf.c
  group sdk_app
    ./../../../../../sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../../../../../sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ../../../../../sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../../../../../sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../../../../../sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ./../../../../../sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ./../../../../../sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ./../../../../../sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ./../../../../../sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../../../../../sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_timer.c
    ../../../../../sdk/app_modules/src/app_easy/: app_easy_security.c
    ./../../../../../sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ../../../../../sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ../../../../../sdk/app_modules/src/app_common/: app_utils.c
  group sdk_driver_api
    ../../../../../sdk/platform/driver/adc/: adc.h
    ../../../../../sdk/platform/driver/battery/: battery.h
    ../../../../../sdk/platform/driver/gpio/: gpio.h
    ../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../../../../sdk/platform/driver/spi/: spi.h
    ../../../../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../../../../sdk/platform/driver/systick/: systick.h
    ../../../../../sdk/platform/driver/trng/: trng.h
    ../../../../../sdk/platform/driver/uart/: uart.h
    ../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    ../../../../../sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    ../../../../../sdk/platform/arch/: arch_api.h
    ../../../../../sdk/platform/arch/main/: arch_wdg.h
    ../../../../../sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_custs1_impl.c user_IR_remote.c
  group user_driver
    ../src/user_driver/: user_IR_driver.c
target ble_IR_remotel_586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: as above
  output: ble_app_peripheral_586 +hex
  c flags: Optim=4 wLevel=2
  c define: __DA14586__
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\app_modules\api;.\..\..\..\..\..\sdk\app_modules\src\app_bass;.\..\..\..\..\..\sdk\app_modules\src\app_custs;.\..\..\..\..\..\sdk\app_modules\src\app_diss;.\..\..\..\..\..\sdk\app_modules\src\app_findme;.\..\..\..\..\..\sdk\app_modules\src\app_multi_bond;.\..\..\..\..\..\sdk\app_modules\src\app_proxr;.\..\..\..\..\..\sdk\app_modules\src\app_suotar;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\ble_stack\ea\api;.\..\..\..\..\..\sdk\ble_stack\em\api;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\hcih;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\ble_stack\profiles\accel;.\..\..\..\..\..\sdk\ble_stack\profiles\adc_notify;.\..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc;.\..\..\..\..\..\sdk\ble_stack\profiles\anc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc;.\..\..\..\..\..\sdk\ble_stack\profiles\anp\anps;.\..\..\..\..\..\sdk\ble_stack\profiles\anp;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\basc;.\..\..\..\..\..\sdk\ble_stack\profiles\bas\bass;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc;.\..\..\..\..\..\sdk\ble_stack\profiles\blp\blps;.\..\..\..\..\..\sdk\ble_stack\profiles\blp;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps;.\..\..\..\..\..\sdk\ble_stack\profiles\cpp;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps;.\..\..\..\..\..\sdk\ble_stack\profiles\cscp;.\..\..\..\..\..\sdk\ble_stack\profiles\custom;.\..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api;.\..\..\..\..\..\sdk\ble_stack\profiles\device_config;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\disc;.\..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findl;.\..\..\..\..\..\sdk\ble_stack\profiles\find\findt;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc;.\..\..\..\..\..\sdk\ble_stack\profiles\glp\glps;.\..\..\..\..\..\sdk\ble_stack\profiles\glp;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh;.\..\..\..\..\..\sdk\ble_stack\profiles\hogp;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps;.\..\..\..\..\..\sdk\ble_stack\profiles\hrp;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc;.\..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt;.\..\..\..\..\..\sdk\ble_stack\profiles\htp;.\..\..\..\..\..\sdk\ble_stack\profiles\ieu;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc;.\..\..\..\..\..\sdk\ble_stack\profiles\lan\lans;.\..\..\..\..\..\sdk\ble_stack\profiles\lan;.\..\..\..\..\..\sdk\ble_stack\profiles\mpu;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps;.\..\..\..\..\..\sdk\ble_stack\profiles\pasp;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm;.\..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps;.\..\..\..\..\..\sdk\ble_stack\profiles\rscp;.\..\..\..\..\..\sdk\ble_stack\profiles\sample128;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps;.\..\..\..\..\..\sdk\ble_stack\profiles\scpp;.\..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_client;.\..\..\..\..\..\sdk\ble_stack\profiles\sps\sps_server;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\..\..\..\..\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc;.\..\..\..\..\..\sdk\ble_stack\profiles\tip\tips;.\..\..\..\..\..\sdk\ble_stack\profiles\tip;.\..\..\..\..\..\sdk\ble_stack\profiles\uds\udss;.\..\..\..\..\..\sdk\ble_stack\profiles\uds;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wptc;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt\wpts;.\..\..\..\..\..\sdk\ble_stack\profiles\wpt;.\..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss;.\..\..\..\..\..\sdk\ble_stack\hci\api;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\crypto;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\h4tl\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\platform\core_modules\wlan_coex;.\..\..\..\..\..\sdk\platform\driver\accel;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\battery;.\..\..\..\..\..\sdk\platform\driver\ble;.\..\..\..\..\..\sdk\platform\driver\bme280;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\coex;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\platform\driver\hw_otpc;.\..\..\..\..\..\sdk\platform\driver\i2c_BMI055;.\..\..\..\..\..\sdk\platform\driver\i2c_core;.\..\..\..\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\driver\inv;.\..\..\..\..\..\sdk\platform\driver\led;.\..\..\..\..\..\sdk\platform\driver\mc3410;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\rc5;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\driver\sensor;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk\platform\driver\spi_flash;.\..\..\..\..\..\sdk\platform\driver\spi_hci;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\trng;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\wkupct_quadec;.\..\..\..\..\..\sdk\platform\system_library\include;.\..\src\config;.\..\src;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;..\src\custom_profile;..\..\..\..\..\third_party\rand;..\..\..\..\..\third_party\hash
  library: MicroLIB
  scatter file: as above
  link misc: --feedback=".\unused_586.txt" .\..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.txt --symdefs=ble_app_peripheral_586_symdef.txt --any_placement=best_fit --datacompressor off
