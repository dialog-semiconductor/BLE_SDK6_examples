# Keil uVision project mCube_mc36xx.uvprojx, settings and files
target DA14585 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_barebone_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;..\src\user_app;..\src\user_drivers;..\src\user_drivers\platform;..\src\user_drivers\platform\bus;..\src\user_drivers\sensor;..\src\user_drivers\sensor\accel;..\src\user_drivers\sensor\accel\mc36xx;C:\DiaSemi\6.0.14.1114_clean\sdk;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\api;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_ancc;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bass;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bcss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bmss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bond_db;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_common;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_ctsc;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_ctss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_custs;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_default_hnd;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_diss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_easy;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_entry;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_findme;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_gattc;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_proxr;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_sec;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_suotar;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_udss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_wsss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\em;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\llc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\lld;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\llm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\ea;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\ea\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\em;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\em\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\hci;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\hci\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\hci\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att\attc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att\attm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att\atts;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gap;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gap\gapc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gap\gapm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gatt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gatt\gattc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gatt\gattm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\l2c;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\l2c\l2cc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\l2c\l2cm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\smp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\smp\smpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\smp\smpm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc\ancc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc\ancc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc\ancc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\basc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\basc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\basc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\bass;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\bass\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\bass\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cppc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cppc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cppc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cpps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cpps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cpps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom\custs;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom\custs\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom\custs\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\disc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\disc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\disc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\diss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\diss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\diss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findl;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findl\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findl\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findt\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findt\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt\gatt_client;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpbh;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpd;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpd\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpd\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogprh;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogprh\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogprh\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpt\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpt\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lanc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lanc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lanc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lans;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lans\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lans\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\paspc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\paspc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\paspc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\pasps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\pasps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\pasps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxm\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxm\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxr;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxr\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxr\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scppc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scppc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scppc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scpps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scpps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scpps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota\suotar;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota\suotar\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota\suotar\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tipc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tipc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tipc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tips;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tips\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tips\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wssc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wssc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wssc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wsss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wsss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wsss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\rwble;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\rwble_hl;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\ldscripts;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\misc;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\scatterfiles;C:\DiaSemi\6.0.14.1114_clean\sdk\platform;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot\ARM;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot\GCC;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler\ARM;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler\GCC;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\ll;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\main;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\arch_console;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\common;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\common\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\crypto;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\dbg;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\dbg\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\gtl;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\gtl\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\gtl\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\h4tl;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\h4tl\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\ke;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\ke\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\ke\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\nvds;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\nvds\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\nvds\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rf;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rf\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rf\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rwip;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rwip\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rwip\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\adc;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\battery;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\ble;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\dma;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\gpio;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\hw_otpc;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\i2c;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\i2c_eeprom;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\pdm;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\reg;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\rtc;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\spi;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\spi_flash;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\syscntl;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\systick;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\timer;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\trng;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\uart;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\wifi;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\wkupct_quadec;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include\CMSIS;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include\CMSIS\5.6.0;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include\CMSIS\5.6.0\Include;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\include;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\output;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\output\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\output\Keil_5;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\utilities;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\utilities\otp_cs;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\utilities\otp_hdr;C:\DiaSemi\6.0.14.1114_clean\third_party;C:\DiaSemi\6.0.14.1114_clean\third_party\crc32;C:\DiaSemi\6.0.14.1114_clean\third_party\hash;C:\DiaSemi\6.0.14.1114_clean\third_party\irng;C:\DiaSemi\6.0.14.1114_clean\third_party\micro_ecc;C:\DiaSemi\6.0.14.1114_clean\third_party\rand
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\misc\da14585_symbols.txt --symdefs=ble_app_barebone_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/core_modules/arch_console/: arch_console.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/core_modules/nvds/src/: nvds.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_hibernation.c arch_rom.c
    C:/DiaSemi/6.0.14.1114_clean/third_party/rand/: chacha20.c
    C:/DiaSemi/6.0.14.1114_clean/third_party/hash/: hash.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/system_library/output/Keil_5/: da14585_586.lib da14531.lib
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/utilities/otp_cs/: otp_cs.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/syscntl/: syscntl.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/gpio/: gpio.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/battery/: battery.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/i2c/: i2c.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/uart/: uart.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/trng/: trng.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/driver/dma/: dma.c
  group sdk_ble
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/ble_stack/rwble/: rwble.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    C:/DiaSemi/6.0.14.1114_clean/sdk/ble_stack/profiles/: prf.c prf_utils.c prf_utils_128.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/ble_stack/profiles/custom/: custom_common.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/ble_stack/host/att/attm/: attm_db_128.c
  group sdk_app
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_entry/: app_entry_point.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_easy/: app_easy_timer.c app_easy_security.c app_easy_msg_utils.c app_easy_whitelist.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_bond_db/: app_bond_db.c
    C:/DiaSemi/6.0.14.1114_clean/sdk/app_modules/src/app_custs/: app_customs.c app_customs_common.c app_customs_task.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/user_app/: user_accelerometer.c
  group user_driver
    ../src/user_drivers/sensor/accel/: m_drv_mc_utility.c
    ../src/user_drivers/sensor/accel/mc36xx/: m_drv_mc36xx.c
    ../src/user_drivers/platform/bus/: m_drv_interface.c
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: ble_app_barebone_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14586__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;..\src\user_app;..\src\user_drivers;..\src\user_drivers\platform;..\src\user_drivers\platform\bus;..\src\user_drivers\sensor;..\src\user_drivers\sensor\accel;..\src\user_drivers\sensor\accel\mc36xx;C:\DiaSemi\6.0.14.1114_clean\sdk;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\api;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_ancc;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bass;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bcss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bmss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_bond_db;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_common;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_ctsc;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_ctss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_custs;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_default_hnd;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_diss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_easy;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_entry;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_findme;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_gattc;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_proxr;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_sec;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_suotar;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_udss;C:\DiaSemi\6.0.14.1114_clean\sdk\app_modules\src\app_wsss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\em;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\llc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\lld;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\controller\llm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\ea;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\ea\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\em;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\em\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\hci;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\hci\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\hci\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att\attc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att\attm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\att\atts;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gap;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gap\gapc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gap\gapm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gatt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gatt\gattc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\gatt\gattm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\l2c;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\l2c\l2cc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\l2c\l2cm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\smp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\smp\smpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\host\smp\smpm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc\ancc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc\ancc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anc\ancc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\anp\anps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\basc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\basc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\basc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\bass;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\bass\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bas\bass\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bcs\bcss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\blp\blps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\bms\bmss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cppc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cppc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cppc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cpps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cpps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cpp\cpps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cscp\cscps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\cts\ctss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom\custs;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom\custs\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\custom\custs\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\disc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\disc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\disc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\diss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\diss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\dis\diss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findl;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findl\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findl\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findt\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\find\findt\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt\gatt_client;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\glp\glps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpbh;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpd;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpd\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogpd\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogprh;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogprh\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hogp\hogprh\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\hrp\hrps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpt;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpt\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\htp\htpt\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lanc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lanc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lanc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lans;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lans\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\lan\lans\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\paspc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\paspc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\paspc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\pasps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\pasps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\pasp\pasps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxm;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxm\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxm\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxr;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxr\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\prox\proxr\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscpc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscpc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscpc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\rscp\rscps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scppc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scppc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scppc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scpps;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scpps\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\scpp\scpps\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota\suotar;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota\suotar\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\suota\suotar\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tipc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tipc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tipc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tips;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tips\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\tip\tips\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udsc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udsc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udsc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\uds\udss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wssc;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wssc\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wssc\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wsss;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wsss\api;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\profiles\wss\wsss\src;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\rwble;C:\DiaSemi\6.0.14.1114_clean\sdk\ble_stack\rwble_hl;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\ldscripts;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\misc;C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\scatterfiles;C:\DiaSemi\6.0.14.1114_clean\sdk\platform;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot\ARM;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot\GCC;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\boot\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler\ARM;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler\GCC;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\compiler\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\ll;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\arch\main;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\arch_console;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\common;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\common\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\crypto;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\dbg;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\dbg\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\gtl;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\gtl\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\gtl\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\h4tl;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\h4tl\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\ke;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\ke\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\ke\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\nvds;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\nvds\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\nvds\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rf;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rf\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rf\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rwip;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rwip\api;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\core_modules\rwip\src;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\adc;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\battery;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\ble;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\dma;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\gpio;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\hw_otpc;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\i2c;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\i2c_eeprom;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\pdm;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\reg;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\rtc;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\spi;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\spi_flash;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\syscntl;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\systick;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\timer;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\trng;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\uart;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\wifi;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\driver\wkupct_quadec;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include\CMSIS;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include\CMSIS\5.6.0;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\include\CMSIS\5.6.0\Include;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\include;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\output;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\output\IAR;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\system_library\output\Keil_5;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\utilities;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\utilities\otp_cs;C:\DiaSemi\6.0.14.1114_clean\sdk\platform\utilities\otp_hdr;C:\DiaSemi\6.0.14.1114_clean\third_party;C:\DiaSemi\6.0.14.1114_clean\third_party\crc32;C:\DiaSemi\6.0.14.1114_clean\third_party\hash;C:\DiaSemi\6.0.14.1114_clean\third_party\irng;C:\DiaSemi\6.0.14.1114_clean\third_party\micro_ecc;C:\DiaSemi\6.0.14.1114_clean\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\misc\da14585_symbols.txt --symdefs=ble_app_barebone_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_barebone_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" C:\DiaSemi\6.0.14.1114_clean\sdk\common_project_files\misc\da14531_symbols.txt --symdefs=ble_app_barebone_531_symdef.txt --any_placement=best_fit --datacompressor off
