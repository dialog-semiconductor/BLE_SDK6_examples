# Keil uVision project spi_master_demo.uvprojx, settings and files
target DA14531_MASTER (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: spi_master_demo +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14531__ CFG_SPI_DMA_SUPPORT __NON_BLE_EXAMPLE__
  c misc: --thumb -c --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;C:\dev\6.0.16.1144\sdk;C:\dev\6.0.16.1144\sdk\app_modules;C:\dev\6.0.16.1144\sdk\app_modules\api;C:\dev\6.0.16.1144\sdk\app_modules\src;C:\dev\6.0.16.1144\sdk\app_modules\src\app_ancc;C:\dev\6.0.16.1144\sdk\app_modules\src\app_bass;C:\dev\6.0.16.1144\sdk\app_modules\src\app_bcss;C:\dev\6.0.16.1144\sdk\app_modules\src\app_bmss;C:\dev\6.0.16.1144\sdk\app_modules\src\app_bond_db;C:\dev\6.0.16.1144\sdk\app_modules\src\app_common;C:\dev\6.0.16.1144\sdk\app_modules\src\app_ctsc;C:\dev\6.0.16.1144\sdk\app_modules\src\app_ctss;C:\dev\6.0.16.1144\sdk\app_modules\src\app_custs;C:\dev\6.0.16.1144\sdk\app_modules\src\app_default_hnd;C:\dev\6.0.16.1144\sdk\app_modules\src\app_diss;C:\dev\6.0.16.1144\sdk\app_modules\src\app_easy;C:\dev\6.0.16.1144\sdk\app_modules\src\app_entry;C:\dev\6.0.16.1144\sdk\app_modules\src\app_findme;C:\dev\6.0.16.1144\sdk\app_modules\src\app_gattc;C:\dev\6.0.16.1144\sdk\app_modules\src\app_proxr;C:\dev\6.0.16.1144\sdk\app_modules\src\app_sec;C:\dev\6.0.16.1144\sdk\app_modules\src\app_suotar;C:\dev\6.0.16.1144\sdk\app_modules\src\app_udss;C:\dev\6.0.16.1144\sdk\app_modules\src\app_wsss;C:\dev\6.0.16.1144\sdk\ble_stack;C:\dev\6.0.16.1144\sdk\ble_stack\controller;C:\dev\6.0.16.1144\sdk\ble_stack\controller\em;C:\dev\6.0.16.1144\sdk\ble_stack\controller\llc;C:\dev\6.0.16.1144\sdk\ble_stack\controller\lld;C:\dev\6.0.16.1144\sdk\ble_stack\controller\llm;C:\dev\6.0.16.1144\sdk\ble_stack\ea;C:\dev\6.0.16.1144\sdk\ble_stack\ea\api;C:\dev\6.0.16.1144\sdk\ble_stack\em;C:\dev\6.0.16.1144\sdk\ble_stack\em\api;C:\dev\6.0.16.1144\sdk\ble_stack\hci;C:\dev\6.0.16.1144\sdk\ble_stack\hci\api;C:\dev\6.0.16.1144\sdk\ble_stack\hci\src;C:\dev\6.0.16.1144\sdk\ble_stack\host;C:\dev\6.0.16.1144\sdk\ble_stack\host\att;C:\dev\6.0.16.1144\sdk\ble_stack\host\att\attc;C:\dev\6.0.16.1144\sdk\ble_stack\host\att\attm;C:\dev\6.0.16.1144\sdk\ble_stack\host\att\atts;C:\dev\6.0.16.1144\sdk\ble_stack\host\gap;C:\dev\6.0.16.1144\sdk\ble_stack\host\gap\gapc;C:\dev\6.0.16.1144\sdk\ble_stack\host\gap\gapm;C:\dev\6.0.16.1144\sdk\ble_stack\host\gatt;C:\dev\6.0.16.1144\sdk\ble_stack\host\gatt\gattc;C:\dev\6.0.16.1144\sdk\ble_stack\host\gatt\gattm;C:\dev\6.0.16.1144\sdk\ble_stack\host\l2c;C:\dev\6.0.16.1144\sdk\ble_stack\host\l2c\l2cc;C:\dev\6.0.16.1144\sdk\ble_stack\host\l2c\l2cm;C:\dev\6.0.16.1144\sdk\ble_stack\host\smp;C:\dev\6.0.16.1144\sdk\ble_stack\host\smp\smpc;C:\dev\6.0.16.1144\sdk\ble_stack\host\smp\smpm;C:\dev\6.0.16.1144\sdk\ble_stack\profiles;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anc\ancc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp\anpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp\anps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp\anps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\anp\anps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas\basc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas\basc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas\basc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas\bass;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas\bass\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bas\bass\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcsc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bcs\bcss\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp\blpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp\blps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp\blps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\blp\blps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms\bmsc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\bms\bmss\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp\cppc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cpp\cpps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cscp\cscps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts\ctsc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\cts\ctss\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\custom;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\custom\custs;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\custom\custs\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\custom\custs\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis\disc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis\disc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis\disc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis\diss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis\diss\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\dis\diss\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find\findl;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find\findl\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find\findl\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find\findt;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find\findt\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\find\findt\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\gatt;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\gatt\gatt_client\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp\glpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp\glps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp\glps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\glp\glps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpbh\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogpd\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hogp\hogprh\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\hrp\hrps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp\htpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\htp\htpt\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan\lanc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan\lans;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan\lans\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\lan\lans\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp\paspc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\pasp\pasps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox\proxm\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\prox\proxr\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscpc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\rscp\rscps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp\scppc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\scpp\scpps\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\suota;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\suota\suotar\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip\tipc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip\tips;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip\tips\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\tip\tips\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds\udsc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds\udss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds\udss\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\uds\udss\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss\wssc\src;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss\api;C:\dev\6.0.16.1144\sdk\ble_stack\profiles\wss\wsss\src;C:\dev\6.0.16.1144\sdk\ble_stack\rwble;C:\dev\6.0.16.1144\sdk\ble_stack\rwble_hl;C:\dev\6.0.16.1144\sdk\common_project_files;C:\dev\6.0.16.1144\sdk\common_project_files\IAR;C:\dev\6.0.16.1144\sdk\common_project_files\ldscripts;C:\dev\6.0.16.1144\sdk\common_project_files\misc;C:\dev\6.0.16.1144\sdk\common_project_files\scatterfiles;C:\dev\6.0.16.1144\sdk\platform;C:\dev\6.0.16.1144\sdk\platform\arch;C:\dev\6.0.16.1144\sdk\platform\arch\boot;C:\dev\6.0.16.1144\sdk\platform\arch\boot\ARM;C:\dev\6.0.16.1144\sdk\platform\arch\boot\GCC;C:\dev\6.0.16.1144\sdk\platform\arch\boot\IAR;C:\dev\6.0.16.1144\sdk\platform\arch\compiler;C:\dev\6.0.16.1144\sdk\platform\arch\compiler\ARM;C:\dev\6.0.16.1144\sdk\platform\arch\compiler\GCC;C:\dev\6.0.16.1144\sdk\platform\arch\compiler\IAR;C:\dev\6.0.16.1144\sdk\platform\arch\ll;C:\dev\6.0.16.1144\sdk\platform\arch\main;C:\dev\6.0.16.1144\sdk\platform\core_modules;C:\dev\6.0.16.1144\sdk\platform\core_modules\arch_console;C:\dev\6.0.16.1144\sdk\platform\core_modules\common;C:\dev\6.0.16.1144\sdk\platform\core_modules\common\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\crypto;C:\dev\6.0.16.1144\sdk\platform\core_modules\dbg;C:\dev\6.0.16.1144\sdk\platform\core_modules\dbg\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\gtl;C:\dev\6.0.16.1144\sdk\platform\core_modules\gtl\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\gtl\src;C:\dev\6.0.16.1144\sdk\platform\core_modules\h4tl;C:\dev\6.0.16.1144\sdk\platform\core_modules\h4tl\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\ke;C:\dev\6.0.16.1144\sdk\platform\core_modules\ke\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\ke\src;C:\dev\6.0.16.1144\sdk\platform\core_modules\nvds;C:\dev\6.0.16.1144\sdk\platform\core_modules\nvds\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\nvds\src;C:\dev\6.0.16.1144\sdk\platform\core_modules\rf;C:\dev\6.0.16.1144\sdk\platform\core_modules\rf\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\rf\src;C:\dev\6.0.16.1144\sdk\platform\core_modules\rwip;C:\dev\6.0.16.1144\sdk\platform\core_modules\rwip\api;C:\dev\6.0.16.1144\sdk\platform\core_modules\rwip\src;C:\dev\6.0.16.1144\sdk\platform\driver;C:\dev\6.0.16.1144\sdk\platform\driver\adc;C:\dev\6.0.16.1144\sdk\platform\driver\battery;C:\dev\6.0.16.1144\sdk\platform\driver\ble;C:\dev\6.0.16.1144\sdk\platform\driver\dma;C:\dev\6.0.16.1144\sdk\platform\driver\gpio;C:\dev\6.0.16.1144\sdk\platform\driver\hw_otpc;C:\dev\6.0.16.1144\sdk\platform\driver\i2c;C:\dev\6.0.16.1144\sdk\platform\driver\i2c_eeprom;C:\dev\6.0.16.1144\sdk\platform\driver\pdm;C:\dev\6.0.16.1144\sdk\platform\driver\reg;C:\dev\6.0.16.1144\sdk\platform\driver\rtc;C:\dev\6.0.16.1144\sdk\platform\driver\spi;C:\dev\6.0.16.1144\sdk\platform\driver\spi_flash;C:\dev\6.0.16.1144\sdk\platform\driver\syscntl;C:\dev\6.0.16.1144\sdk\platform\driver\systick;C:\dev\6.0.16.1144\sdk\platform\driver\timer;C:\dev\6.0.16.1144\sdk\platform\driver\trng;C:\dev\6.0.16.1144\sdk\platform\driver\uart;C:\dev\6.0.16.1144\sdk\platform\driver\wifi;C:\dev\6.0.16.1144\sdk\platform\driver\wkupct_quadec;C:\dev\6.0.16.1144\sdk\platform\include;C:\dev\6.0.16.1144\sdk\platform\include\CMSIS;C:\dev\6.0.16.1144\sdk\platform\include\CMSIS\5.6.0;C:\dev\6.0.16.1144\sdk\platform\include\CMSIS\5.6.0\Include;C:\dev\6.0.16.1144\sdk\platform\system_library;C:\dev\6.0.16.1144\sdk\platform\system_library\include;C:\dev\6.0.16.1144\sdk\platform\system_library\output;C:\dev\6.0.16.1144\sdk\platform\system_library\output\IAR;C:\dev\6.0.16.1144\sdk\platform\system_library\output\Keil_5;C:\dev\6.0.16.1144\sdk\platform\utilities;C:\dev\6.0.16.1144\sdk\platform\utilities\otp_cs;C:\dev\6.0.16.1144\sdk\platform\utilities\otp_hdr;C:\dev\6.0.16.1144\third_party;C:\dev\6.0.16.1144\third_party\crc32;C:\dev\6.0.16.1144\third_party\hash;C:\dev\6.0.16.1144\third_party\irng;C:\dev\6.0.16.1144\third_party\micro_ecc;C:\dev\6.0.16.1144\third_party\rand
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: C:\dev\6.0.16.1144\projects\target_apps\peripheral_examples\shared\peripheral_examples.sct
  group sdk_boot
    C:/dev/6.0.16.1144/sdk/platform/arch/boot/ARM/: startup_DA14531.s
    C:/dev/6.0.16.1144/sdk/platform/arch/boot/: system_DA14531.c
    C:/dev/6.0.16.1144/projects/target_apps/peripheral_examples/shared/source/: exceptions.c
  group sdk_driver
    C:/dev/6.0.16.1144/sdk/platform/driver/syscntl/: syscntl.c
    C:/dev/6.0.16.1144/sdk/platform/driver/gpio/: gpio.c
    C:/dev/6.0.16.1144/sdk/platform/driver/dma/: dma.c
    C:/dev/6.0.16.1144/sdk/platform/driver/uart/: uart.c uart_utils.c
    C:/dev/6.0.16.1144/sdk/platform/driver/spi/: spi_531.c
    C:/dev/6.0.16.1144/sdk/platform/driver/spi_flash/: spi_flash.c
    C:/dev/6.0.16.1144/sdk/platform/driver/hw_otpc/: hw_otpc_531.c
    C:/dev/6.0.16.1144/sdk/platform/utilities/otp_cs/: otp_cs.c
  group user_app
    ../src/: main.c user_periph_setup.c
    C:/dev/6.0.16.1144/sdk/platform/arch/main/: arch_system.c
