# Keil uVision project simple_button.uvprojx, settings and files
target simple_button_585 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simple_button_585 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c
  c include: ..\include;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\compiler\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\arch\ll\rvds;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\reg;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\include;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\gpio;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\app_modules\api;C:\DA14585_untouched_SDK\6.0.10.511\projects\target_apps\peripheral_examples\shared\common_uart;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\uart;C:\DA14585_untouched_SDK\6.0.10.511\\sdk\platform\driver\systick
  library: MicroLIB
  scatter file: C:\DA14585_untouched_SDK\6.0.10.511\projects\target_apps\peripheral_examples\shared\peripheral_examples.sct
  group boot
    C:/DA14585_untouched_SDK/6.0.10.511/projects/target_apps/peripheral_examples/shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/gpio/: gpio.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/uart/: uart2.c
    C:/DA14585_untouched_SDK/6.0.10.511//sdk/platform/driver/systick/: systick.c
  group common_uart
    C:/DA14585_untouched_SDK/6.0.10.511/projects/target_apps/peripheral_examples/shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
